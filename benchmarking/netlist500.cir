*500
V1 1 0 SINE(0 100 1)
R1 1 2 1
R501 1 0 1000
R2 2 3 1
R502 2 0 1000
R3 3 4 1
R503 3 0 1000
R4 4 5 1
R504 4 0 1000
R5 5 6 1
R505 5 0 1000
R6 6 7 1
R506 6 0 1000
R7 7 8 1
R507 7 0 1000
R8 8 9 1
R508 8 0 1000
R9 9 10 1
R509 9 0 1000
R10 10 11 1
R510 10 0 1000
R11 11 12 1
R511 11 0 1000
R12 12 13 1
R512 12 0 1000
R13 13 14 1
R513 13 0 1000
R14 14 15 1
R514 14 0 1000
R15 15 16 1
R515 15 0 1000
R16 16 17 1
R516 16 0 1000
R17 17 18 1
R517 17 0 1000
R18 18 19 1
R518 18 0 1000
R19 19 20 1
R519 19 0 1000
R20 20 21 1
R520 20 0 1000
R21 21 22 1
R521 21 0 1000
R22 22 23 1
R522 22 0 1000
R23 23 24 1
R523 23 0 1000
R24 24 25 1
R524 24 0 1000
R25 25 26 1
R525 25 0 1000
R26 26 27 1
R526 26 0 1000
R27 27 28 1
R527 27 0 1000
R28 28 29 1
R528 28 0 1000
R29 29 30 1
R529 29 0 1000
R30 30 31 1
R530 30 0 1000
R31 31 32 1
R531 31 0 1000
R32 32 33 1
R532 32 0 1000
R33 33 34 1
R533 33 0 1000
R34 34 35 1
R534 34 0 1000
R35 35 36 1
R535 35 0 1000
R36 36 37 1
R536 36 0 1000
R37 37 38 1
R537 37 0 1000
R38 38 39 1
R538 38 0 1000
R39 39 40 1
R539 39 0 1000
R40 40 41 1
R540 40 0 1000
R41 41 42 1
R541 41 0 1000
R42 42 43 1
R542 42 0 1000
R43 43 44 1
R543 43 0 1000
R44 44 45 1
R544 44 0 1000
R45 45 46 1
R545 45 0 1000
R46 46 47 1
R546 46 0 1000
R47 47 48 1
R547 47 0 1000
R48 48 49 1
R548 48 0 1000
R49 49 50 1
R549 49 0 1000
R50 50 51 1
R550 50 0 1000
R51 51 52 1
R551 51 0 1000
R52 52 53 1
R552 52 0 1000
R53 53 54 1
R553 53 0 1000
R54 54 55 1
R554 54 0 1000
R55 55 56 1
R555 55 0 1000
R56 56 57 1
R556 56 0 1000
R57 57 58 1
R557 57 0 1000
R58 58 59 1
R558 58 0 1000
R59 59 60 1
R559 59 0 1000
R60 60 61 1
R560 60 0 1000
R61 61 62 1
R561 61 0 1000
R62 62 63 1
R562 62 0 1000
R63 63 64 1
R563 63 0 1000
R64 64 65 1
R564 64 0 1000
R65 65 66 1
R565 65 0 1000
R66 66 67 1
R566 66 0 1000
R67 67 68 1
R567 67 0 1000
R68 68 69 1
R568 68 0 1000
R69 69 70 1
R569 69 0 1000
R70 70 71 1
R570 70 0 1000
R71 71 72 1
R571 71 0 1000
R72 72 73 1
R572 72 0 1000
R73 73 74 1
R573 73 0 1000
R74 74 75 1
R574 74 0 1000
R75 75 76 1
R575 75 0 1000
R76 76 77 1
R576 76 0 1000
R77 77 78 1
R577 77 0 1000
R78 78 79 1
R578 78 0 1000
R79 79 80 1
R579 79 0 1000
R80 80 81 1
R580 80 0 1000
R81 81 82 1
R581 81 0 1000
R82 82 83 1
R582 82 0 1000
R83 83 84 1
R583 83 0 1000
R84 84 85 1
R584 84 0 1000
R85 85 86 1
R585 85 0 1000
R86 86 87 1
R586 86 0 1000
R87 87 88 1
R587 87 0 1000
R88 88 89 1
R588 88 0 1000
R89 89 90 1
R589 89 0 1000
R90 90 91 1
R590 90 0 1000
R91 91 92 1
R591 91 0 1000
R92 92 93 1
R592 92 0 1000
R93 93 94 1
R593 93 0 1000
R94 94 95 1
R594 94 0 1000
R95 95 96 1
R595 95 0 1000
R96 96 97 1
R596 96 0 1000
R97 97 98 1
R597 97 0 1000
R98 98 99 1
R598 98 0 1000
R99 99 100 1
R599 99 0 1000
R100 100 101 1
R600 100 0 1000
R101 101 102 1
R601 101 0 1000
R102 102 103 1
R602 102 0 1000
R103 103 104 1
R603 103 0 1000
R104 104 105 1
R604 104 0 1000
R105 105 106 1
R605 105 0 1000
R106 106 107 1
R606 106 0 1000
R107 107 108 1
R607 107 0 1000
R108 108 109 1
R608 108 0 1000
R109 109 110 1
R609 109 0 1000
R110 110 111 1
R610 110 0 1000
R111 111 112 1
R611 111 0 1000
R112 112 113 1
R612 112 0 1000
R113 113 114 1
R613 113 0 1000
R114 114 115 1
R614 114 0 1000
R115 115 116 1
R615 115 0 1000
R116 116 117 1
R616 116 0 1000
R117 117 118 1
R617 117 0 1000
R118 118 119 1
R618 118 0 1000
R119 119 120 1
R619 119 0 1000
R120 120 121 1
R620 120 0 1000
R121 121 122 1
R621 121 0 1000
R122 122 123 1
R622 122 0 1000
R123 123 124 1
R623 123 0 1000
R124 124 125 1
R624 124 0 1000
R125 125 126 1
R625 125 0 1000
R126 126 127 1
R626 126 0 1000
R127 127 128 1
R627 127 0 1000
R128 128 129 1
R628 128 0 1000
R129 129 130 1
R629 129 0 1000
R130 130 131 1
R630 130 0 1000
R131 131 132 1
R631 131 0 1000
R132 132 133 1
R632 132 0 1000
R133 133 134 1
R633 133 0 1000
R134 134 135 1
R634 134 0 1000
R135 135 136 1
R635 135 0 1000
R136 136 137 1
R636 136 0 1000
R137 137 138 1
R637 137 0 1000
R138 138 139 1
R638 138 0 1000
R139 139 140 1
R639 139 0 1000
R140 140 141 1
R640 140 0 1000
R141 141 142 1
R641 141 0 1000
R142 142 143 1
R642 142 0 1000
R143 143 144 1
R643 143 0 1000
R144 144 145 1
R644 144 0 1000
R145 145 146 1
R645 145 0 1000
R146 146 147 1
R646 146 0 1000
R147 147 148 1
R647 147 0 1000
R148 148 149 1
R648 148 0 1000
R149 149 150 1
R649 149 0 1000
R150 150 151 1
R650 150 0 1000
R151 151 152 1
R651 151 0 1000
R152 152 153 1
R652 152 0 1000
R153 153 154 1
R653 153 0 1000
R154 154 155 1
R654 154 0 1000
R155 155 156 1
R655 155 0 1000
R156 156 157 1
R656 156 0 1000
R157 157 158 1
R657 157 0 1000
R158 158 159 1
R658 158 0 1000
R159 159 160 1
R659 159 0 1000
R160 160 161 1
R660 160 0 1000
R161 161 162 1
R661 161 0 1000
R162 162 163 1
R662 162 0 1000
R163 163 164 1
R663 163 0 1000
R164 164 165 1
R664 164 0 1000
R165 165 166 1
R665 165 0 1000
R166 166 167 1
R666 166 0 1000
R167 167 168 1
R667 167 0 1000
R168 168 169 1
R668 168 0 1000
R169 169 170 1
R669 169 0 1000
R170 170 171 1
R670 170 0 1000
R171 171 172 1
R671 171 0 1000
R172 172 173 1
R672 172 0 1000
R173 173 174 1
R673 173 0 1000
R174 174 175 1
R674 174 0 1000
R175 175 176 1
R675 175 0 1000
R176 176 177 1
R676 176 0 1000
R177 177 178 1
R677 177 0 1000
R178 178 179 1
R678 178 0 1000
R179 179 180 1
R679 179 0 1000
R180 180 181 1
R680 180 0 1000
R181 181 182 1
R681 181 0 1000
R182 182 183 1
R682 182 0 1000
R183 183 184 1
R683 183 0 1000
R184 184 185 1
R684 184 0 1000
R185 185 186 1
R685 185 0 1000
R186 186 187 1
R686 186 0 1000
R187 187 188 1
R687 187 0 1000
R188 188 189 1
R688 188 0 1000
R189 189 190 1
R689 189 0 1000
R190 190 191 1
R690 190 0 1000
R191 191 192 1
R691 191 0 1000
R192 192 193 1
R692 192 0 1000
R193 193 194 1
R693 193 0 1000
R194 194 195 1
R694 194 0 1000
R195 195 196 1
R695 195 0 1000
R196 196 197 1
R696 196 0 1000
R197 197 198 1
R697 197 0 1000
R198 198 199 1
R698 198 0 1000
R199 199 200 1
R699 199 0 1000
R200 200 201 1
R700 200 0 1000
R201 201 202 1
R701 201 0 1000
R202 202 203 1
R702 202 0 1000
R203 203 204 1
R703 203 0 1000
R204 204 205 1
R704 204 0 1000
R205 205 206 1
R705 205 0 1000
R206 206 207 1
R706 206 0 1000
R207 207 208 1
R707 207 0 1000
R208 208 209 1
R708 208 0 1000
R209 209 210 1
R709 209 0 1000
R210 210 211 1
R710 210 0 1000
R211 211 212 1
R711 211 0 1000
R212 212 213 1
R712 212 0 1000
R213 213 214 1
R713 213 0 1000
R214 214 215 1
R714 214 0 1000
R215 215 216 1
R715 215 0 1000
R216 216 217 1
R716 216 0 1000
R217 217 218 1
R717 217 0 1000
R218 218 219 1
R718 218 0 1000
R219 219 220 1
R719 219 0 1000
R220 220 221 1
R720 220 0 1000
R221 221 222 1
R721 221 0 1000
R222 222 223 1
R722 222 0 1000
R223 223 224 1
R723 223 0 1000
R224 224 225 1
R724 224 0 1000
R225 225 226 1
R725 225 0 1000
R226 226 227 1
R726 226 0 1000
R227 227 228 1
R727 227 0 1000
R228 228 229 1
R728 228 0 1000
R229 229 230 1
R729 229 0 1000
R230 230 231 1
R730 230 0 1000
R231 231 232 1
R731 231 0 1000
R232 232 233 1
R732 232 0 1000
R233 233 234 1
R733 233 0 1000
R234 234 235 1
R734 234 0 1000
R235 235 236 1
R735 235 0 1000
R236 236 237 1
R736 236 0 1000
R237 237 238 1
R737 237 0 1000
R238 238 239 1
R738 238 0 1000
R239 239 240 1
R739 239 0 1000
R240 240 241 1
R740 240 0 1000
R241 241 242 1
R741 241 0 1000
R242 242 243 1
R742 242 0 1000
R243 243 244 1
R743 243 0 1000
R244 244 245 1
R744 244 0 1000
R245 245 246 1
R745 245 0 1000
R246 246 247 1
R746 246 0 1000
R247 247 248 1
R747 247 0 1000
R248 248 249 1
R748 248 0 1000
R249 249 250 1
R749 249 0 1000
R250 250 251 1
R750 250 0 1000
R251 251 252 1
R751 251 0 1000
R252 252 253 1
R752 252 0 1000
R253 253 254 1
R753 253 0 1000
R254 254 255 1
R754 254 0 1000
R255 255 256 1
R755 255 0 1000
R256 256 257 1
R756 256 0 1000
R257 257 258 1
R757 257 0 1000
R258 258 259 1
R758 258 0 1000
R259 259 260 1
R759 259 0 1000
R260 260 261 1
R760 260 0 1000
R261 261 262 1
R761 261 0 1000
R262 262 263 1
R762 262 0 1000
R263 263 264 1
R763 263 0 1000
R264 264 265 1
R764 264 0 1000
R265 265 266 1
R765 265 0 1000
R266 266 267 1
R766 266 0 1000
R267 267 268 1
R767 267 0 1000
R268 268 269 1
R768 268 0 1000
R269 269 270 1
R769 269 0 1000
R270 270 271 1
R770 270 0 1000
R271 271 272 1
R771 271 0 1000
R272 272 273 1
R772 272 0 1000
R273 273 274 1
R773 273 0 1000
R274 274 275 1
R774 274 0 1000
R275 275 276 1
R775 275 0 1000
R276 276 277 1
R776 276 0 1000
R277 277 278 1
R777 277 0 1000
R278 278 279 1
R778 278 0 1000
R279 279 280 1
R779 279 0 1000
R280 280 281 1
R780 280 0 1000
R281 281 282 1
R781 281 0 1000
R282 282 283 1
R782 282 0 1000
R283 283 284 1
R783 283 0 1000
R284 284 285 1
R784 284 0 1000
R285 285 286 1
R785 285 0 1000
R286 286 287 1
R786 286 0 1000
R287 287 288 1
R787 287 0 1000
R288 288 289 1
R788 288 0 1000
R289 289 290 1
R789 289 0 1000
R290 290 291 1
R790 290 0 1000
R291 291 292 1
R791 291 0 1000
R292 292 293 1
R792 292 0 1000
R293 293 294 1
R793 293 0 1000
R294 294 295 1
R794 294 0 1000
R295 295 296 1
R795 295 0 1000
R296 296 297 1
R796 296 0 1000
R297 297 298 1
R797 297 0 1000
R298 298 299 1
R798 298 0 1000
R299 299 300 1
R799 299 0 1000
R300 300 301 1
R800 300 0 1000
R301 301 302 1
R801 301 0 1000
R302 302 303 1
R802 302 0 1000
R303 303 304 1
R803 303 0 1000
R304 304 305 1
R804 304 0 1000
R305 305 306 1
R805 305 0 1000
R306 306 307 1
R806 306 0 1000
R307 307 308 1
R807 307 0 1000
R308 308 309 1
R808 308 0 1000
R309 309 310 1
R809 309 0 1000
R310 310 311 1
R810 310 0 1000
R311 311 312 1
R811 311 0 1000
R312 312 313 1
R812 312 0 1000
R313 313 314 1
R813 313 0 1000
R314 314 315 1
R814 314 0 1000
R315 315 316 1
R815 315 0 1000
R316 316 317 1
R816 316 0 1000
R317 317 318 1
R817 317 0 1000
R318 318 319 1
R818 318 0 1000
R319 319 320 1
R819 319 0 1000
R320 320 321 1
R820 320 0 1000
R321 321 322 1
R821 321 0 1000
R322 322 323 1
R822 322 0 1000
R323 323 324 1
R823 323 0 1000
R324 324 325 1
R824 324 0 1000
R325 325 326 1
R825 325 0 1000
R326 326 327 1
R826 326 0 1000
R327 327 328 1
R827 327 0 1000
R328 328 329 1
R828 328 0 1000
R329 329 330 1
R829 329 0 1000
R330 330 331 1
R830 330 0 1000
R331 331 332 1
R831 331 0 1000
R332 332 333 1
R832 332 0 1000
R333 333 334 1
R833 333 0 1000
R334 334 335 1
R834 334 0 1000
R335 335 336 1
R835 335 0 1000
R336 336 337 1
R836 336 0 1000
R337 337 338 1
R837 337 0 1000
R338 338 339 1
R838 338 0 1000
R339 339 340 1
R839 339 0 1000
R340 340 341 1
R840 340 0 1000
R341 341 342 1
R841 341 0 1000
R342 342 343 1
R842 342 0 1000
R343 343 344 1
R843 343 0 1000
R344 344 345 1
R844 344 0 1000
R345 345 346 1
R845 345 0 1000
R346 346 347 1
R846 346 0 1000
R347 347 348 1
R847 347 0 1000
R348 348 349 1
R848 348 0 1000
R349 349 350 1
R849 349 0 1000
R350 350 351 1
R850 350 0 1000
R351 351 352 1
R851 351 0 1000
R352 352 353 1
R852 352 0 1000
R353 353 354 1
R853 353 0 1000
R354 354 355 1
R854 354 0 1000
R355 355 356 1
R855 355 0 1000
R356 356 357 1
R856 356 0 1000
R357 357 358 1
R857 357 0 1000
R358 358 359 1
R858 358 0 1000
R359 359 360 1
R859 359 0 1000
R360 360 361 1
R860 360 0 1000
R361 361 362 1
R861 361 0 1000
R362 362 363 1
R862 362 0 1000
R363 363 364 1
R863 363 0 1000
R364 364 365 1
R864 364 0 1000
R365 365 366 1
R865 365 0 1000
R366 366 367 1
R866 366 0 1000
R367 367 368 1
R867 367 0 1000
R368 368 369 1
R868 368 0 1000
R369 369 370 1
R869 369 0 1000
R370 370 371 1
R870 370 0 1000
R371 371 372 1
R871 371 0 1000
R372 372 373 1
R872 372 0 1000
R373 373 374 1
R873 373 0 1000
R374 374 375 1
R874 374 0 1000
R375 375 376 1
R875 375 0 1000
R376 376 377 1
R876 376 0 1000
R377 377 378 1
R877 377 0 1000
R378 378 379 1
R878 378 0 1000
R379 379 380 1
R879 379 0 1000
R380 380 381 1
R880 380 0 1000
R381 381 382 1
R881 381 0 1000
R382 382 383 1
R882 382 0 1000
R383 383 384 1
R883 383 0 1000
R384 384 385 1
R884 384 0 1000
R385 385 386 1
R885 385 0 1000
R386 386 387 1
R886 386 0 1000
R387 387 388 1
R887 387 0 1000
R388 388 389 1
R888 388 0 1000
R389 389 390 1
R889 389 0 1000
R390 390 391 1
R890 390 0 1000
R391 391 392 1
R891 391 0 1000
R392 392 393 1
R892 392 0 1000
R393 393 394 1
R893 393 0 1000
R394 394 395 1
R894 394 0 1000
R395 395 396 1
R895 395 0 1000
R396 396 397 1
R896 396 0 1000
R397 397 398 1
R897 397 0 1000
R398 398 399 1
R898 398 0 1000
R399 399 400 1
R899 399 0 1000
R400 400 401 1
R900 400 0 1000
R401 401 402 1
R901 401 0 1000
R402 402 403 1
R902 402 0 1000
R403 403 404 1
R903 403 0 1000
R404 404 405 1
R904 404 0 1000
R405 405 406 1
R905 405 0 1000
R406 406 407 1
R906 406 0 1000
R407 407 408 1
R907 407 0 1000
R408 408 409 1
R908 408 0 1000
R409 409 410 1
R909 409 0 1000
R410 410 411 1
R910 410 0 1000
R411 411 412 1
R911 411 0 1000
R412 412 413 1
R912 412 0 1000
R413 413 414 1
R913 413 0 1000
R414 414 415 1
R914 414 0 1000
R415 415 416 1
R915 415 0 1000
R416 416 417 1
R916 416 0 1000
R417 417 418 1
R917 417 0 1000
R418 418 419 1
R918 418 0 1000
R419 419 420 1
R919 419 0 1000
R420 420 421 1
R920 420 0 1000
R421 421 422 1
R921 421 0 1000
R422 422 423 1
R922 422 0 1000
R423 423 424 1
R923 423 0 1000
R424 424 425 1
R924 424 0 1000
R425 425 426 1
R925 425 0 1000
R426 426 427 1
R926 426 0 1000
R427 427 428 1
R927 427 0 1000
R428 428 429 1
R928 428 0 1000
R429 429 430 1
R929 429 0 1000
R430 430 431 1
R930 430 0 1000
R431 431 432 1
R931 431 0 1000
R432 432 433 1
R932 432 0 1000
R433 433 434 1
R933 433 0 1000
R434 434 435 1
R934 434 0 1000
R435 435 436 1
R935 435 0 1000
R436 436 437 1
R936 436 0 1000
R437 437 438 1
R937 437 0 1000
R438 438 439 1
R938 438 0 1000
R439 439 440 1
R939 439 0 1000
R440 440 441 1
R940 440 0 1000
R441 441 442 1
R941 441 0 1000
R442 442 443 1
R942 442 0 1000
R443 443 444 1
R943 443 0 1000
R444 444 445 1
R944 444 0 1000
R445 445 446 1
R945 445 0 1000
R446 446 447 1
R946 446 0 1000
R447 447 448 1
R947 447 0 1000
R448 448 449 1
R948 448 0 1000
R449 449 450 1
R949 449 0 1000
R450 450 451 1
R950 450 0 1000
R451 451 452 1
R951 451 0 1000
R452 452 453 1
R952 452 0 1000
R453 453 454 1
R953 453 0 1000
R454 454 455 1
R954 454 0 1000
R455 455 456 1
R955 455 0 1000
R456 456 457 1
R956 456 0 1000
R457 457 458 1
R957 457 0 1000
R458 458 459 1
R958 458 0 1000
R459 459 460 1
R959 459 0 1000
R460 460 461 1
R960 460 0 1000
R461 461 462 1
R961 461 0 1000
R462 462 463 1
R962 462 0 1000
R463 463 464 1
R963 463 0 1000
R464 464 465 1
R964 464 0 1000
R465 465 466 1
R965 465 0 1000
R466 466 467 1
R966 466 0 1000
R467 467 468 1
R967 467 0 1000
R468 468 469 1
R968 468 0 1000
R469 469 470 1
R969 469 0 1000
R470 470 471 1
R970 470 0 1000
R471 471 472 1
R971 471 0 1000
R472 472 473 1
R972 472 0 1000
R473 473 474 1
R973 473 0 1000
R474 474 475 1
R974 474 0 1000
R475 475 476 1
R975 475 0 1000
R476 476 477 1
R976 476 0 1000
R477 477 478 1
R977 477 0 1000
R478 478 479 1
R978 478 0 1000
R479 479 480 1
R979 479 0 1000
R480 480 481 1
R980 480 0 1000
R481 481 482 1
R981 481 0 1000
R482 482 483 1
R982 482 0 1000
R483 483 484 1
R983 483 0 1000
R484 484 485 1
R984 484 0 1000
R485 485 486 1
R985 485 0 1000
R486 486 487 1
R986 486 0 1000
R487 487 488 1
R987 487 0 1000
R488 488 489 1
R988 488 0 1000
R489 489 490 1
R989 489 0 1000
R490 490 491 1
R990 490 0 1000
R491 491 492 1
R991 491 0 1000
R492 492 493 1
R992 492 0 1000
R493 493 494 1
R993 493 0 1000
R494 494 495 1
R994 494 0 1000
R495 495 496 1
R995 495 0 1000
R496 496 497 1
R996 496 0 1000
R497 497 498 1
R997 497 0 1000
R498 498 499 1
R998 498 0 1000
R499 499 500 1
R999 499 0 1000
.tran 0 3 0 0.001
.end
