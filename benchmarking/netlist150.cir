*150
V1 1 0 SINE(0 100 1)
R1 1 2 1
R151 1 0 1000
R2 2 3 1
R152 2 0 1000
R3 3 4 1
R153 3 0 1000
R4 4 5 1
R154 4 0 1000
R5 5 6 1
R155 5 0 1000
R6 6 7 1
R156 6 0 1000
R7 7 8 1
R157 7 0 1000
R8 8 9 1
R158 8 0 1000
R9 9 10 1
R159 9 0 1000
R10 10 11 1
R160 10 0 1000
R11 11 12 1
R161 11 0 1000
R12 12 13 1
R162 12 0 1000
R13 13 14 1
R163 13 0 1000
R14 14 15 1
R164 14 0 1000
R15 15 16 1
R165 15 0 1000
R16 16 17 1
R166 16 0 1000
R17 17 18 1
R167 17 0 1000
R18 18 19 1
R168 18 0 1000
R19 19 20 1
R169 19 0 1000
R20 20 21 1
R170 20 0 1000
R21 21 22 1
R171 21 0 1000
R22 22 23 1
R172 22 0 1000
R23 23 24 1
R173 23 0 1000
R24 24 25 1
R174 24 0 1000
R25 25 26 1
R175 25 0 1000
R26 26 27 1
R176 26 0 1000
R27 27 28 1
R177 27 0 1000
R28 28 29 1
R178 28 0 1000
R29 29 30 1
R179 29 0 1000
R30 30 31 1
R180 30 0 1000
R31 31 32 1
R181 31 0 1000
R32 32 33 1
R182 32 0 1000
R33 33 34 1
R183 33 0 1000
R34 34 35 1
R184 34 0 1000
R35 35 36 1
R185 35 0 1000
R36 36 37 1
R186 36 0 1000
R37 37 38 1
R187 37 0 1000
R38 38 39 1
R188 38 0 1000
R39 39 40 1
R189 39 0 1000
R40 40 41 1
R190 40 0 1000
R41 41 42 1
R191 41 0 1000
R42 42 43 1
R192 42 0 1000
R43 43 44 1
R193 43 0 1000
R44 44 45 1
R194 44 0 1000
R45 45 46 1
R195 45 0 1000
R46 46 47 1
R196 46 0 1000
R47 47 48 1
R197 47 0 1000
R48 48 49 1
R198 48 0 1000
R49 49 50 1
R199 49 0 1000
R50 50 51 1
R200 50 0 1000
R51 51 52 1
R201 51 0 1000
R52 52 53 1
R202 52 0 1000
R53 53 54 1
R203 53 0 1000
R54 54 55 1
R204 54 0 1000
R55 55 56 1
R205 55 0 1000
R56 56 57 1
R206 56 0 1000
R57 57 58 1
R207 57 0 1000
R58 58 59 1
R208 58 0 1000
R59 59 60 1
R209 59 0 1000
R60 60 61 1
R210 60 0 1000
R61 61 62 1
R211 61 0 1000
R62 62 63 1
R212 62 0 1000
R63 63 64 1
R213 63 0 1000
R64 64 65 1
R214 64 0 1000
R65 65 66 1
R215 65 0 1000
R66 66 67 1
R216 66 0 1000
R67 67 68 1
R217 67 0 1000
R68 68 69 1
R218 68 0 1000
R69 69 70 1
R219 69 0 1000
R70 70 71 1
R220 70 0 1000
R71 71 72 1
R221 71 0 1000
R72 72 73 1
R222 72 0 1000
R73 73 74 1
R223 73 0 1000
R74 74 75 1
R224 74 0 1000
R75 75 76 1
R225 75 0 1000
R76 76 77 1
R226 76 0 1000
R77 77 78 1
R227 77 0 1000
R78 78 79 1
R228 78 0 1000
R79 79 80 1
R229 79 0 1000
R80 80 81 1
R230 80 0 1000
R81 81 82 1
R231 81 0 1000
R82 82 83 1
R232 82 0 1000
R83 83 84 1
R233 83 0 1000
R84 84 85 1
R234 84 0 1000
R85 85 86 1
R235 85 0 1000
R86 86 87 1
R236 86 0 1000
R87 87 88 1
R237 87 0 1000
R88 88 89 1
R238 88 0 1000
R89 89 90 1
R239 89 0 1000
R90 90 91 1
R240 90 0 1000
R91 91 92 1
R241 91 0 1000
R92 92 93 1
R242 92 0 1000
R93 93 94 1
R243 93 0 1000
R94 94 95 1
R244 94 0 1000
R95 95 96 1
R245 95 0 1000
R96 96 97 1
R246 96 0 1000
R97 97 98 1
R247 97 0 1000
R98 98 99 1
R248 98 0 1000
R99 99 100 1
R249 99 0 1000
R100 100 101 1
R250 100 0 1000
R101 101 102 1
R251 101 0 1000
R102 102 103 1
R252 102 0 1000
R103 103 104 1
R253 103 0 1000
R104 104 105 1
R254 104 0 1000
R105 105 106 1
R255 105 0 1000
R106 106 107 1
R256 106 0 1000
R107 107 108 1
R257 107 0 1000
R108 108 109 1
R258 108 0 1000
R109 109 110 1
R259 109 0 1000
R110 110 111 1
R260 110 0 1000
R111 111 112 1
R261 111 0 1000
R112 112 113 1
R262 112 0 1000
R113 113 114 1
R263 113 0 1000
R114 114 115 1
R264 114 0 1000
R115 115 116 1
R265 115 0 1000
R116 116 117 1
R266 116 0 1000
R117 117 118 1
R267 117 0 1000
R118 118 119 1
R268 118 0 1000
R119 119 120 1
R269 119 0 1000
R120 120 121 1
R270 120 0 1000
R121 121 122 1
R271 121 0 1000
R122 122 123 1
R272 122 0 1000
R123 123 124 1
R273 123 0 1000
R124 124 125 1
R274 124 0 1000
R125 125 126 1
R275 125 0 1000
R126 126 127 1
R276 126 0 1000
R127 127 128 1
R277 127 0 1000
R128 128 129 1
R278 128 0 1000
R129 129 130 1
R279 129 0 1000
R130 130 131 1
R280 130 0 1000
R131 131 132 1
R281 131 0 1000
R132 132 133 1
R282 132 0 1000
R133 133 134 1
R283 133 0 1000
R134 134 135 1
R284 134 0 1000
R135 135 136 1
R285 135 0 1000
R136 136 137 1
R286 136 0 1000
R137 137 138 1
R287 137 0 1000
R138 138 139 1
R288 138 0 1000
R139 139 140 1
R289 139 0 1000
R140 140 141 1
R290 140 0 1000
R141 141 142 1
R291 141 0 1000
R142 142 143 1
R292 142 0 1000
R143 143 144 1
R293 143 0 1000
R144 144 145 1
R294 144 0 1000
R145 145 146 1
R295 145 0 1000
R146 146 147 1
R296 146 0 1000
R147 147 148 1
R297 147 0 1000
R148 148 149 1
R298 148 0 1000
R149 149 150 1
R299 149 0 1000
.tran 0 3 0 0.001
.end
