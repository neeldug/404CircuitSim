*950
V1 1 0 SINE(0 100 1)
R1 1 2 1
R951 1 0 1000
R2 2 3 1
R952 2 0 1000
R3 3 4 1
R953 3 0 1000
R4 4 5 1
R954 4 0 1000
R5 5 6 1
R955 5 0 1000
R6 6 7 1
R956 6 0 1000
R7 7 8 1
R957 7 0 1000
R8 8 9 1
R958 8 0 1000
R9 9 10 1
R959 9 0 1000
R10 10 11 1
R960 10 0 1000
R11 11 12 1
R961 11 0 1000
R12 12 13 1
R962 12 0 1000
R13 13 14 1
R963 13 0 1000
R14 14 15 1
R964 14 0 1000
R15 15 16 1
R965 15 0 1000
R16 16 17 1
R966 16 0 1000
R17 17 18 1
R967 17 0 1000
R18 18 19 1
R968 18 0 1000
R19 19 20 1
R969 19 0 1000
R20 20 21 1
R970 20 0 1000
R21 21 22 1
R971 21 0 1000
R22 22 23 1
R972 22 0 1000
R23 23 24 1
R973 23 0 1000
R24 24 25 1
R974 24 0 1000
R25 25 26 1
R975 25 0 1000
R26 26 27 1
R976 26 0 1000
R27 27 28 1
R977 27 0 1000
R28 28 29 1
R978 28 0 1000
R29 29 30 1
R979 29 0 1000
R30 30 31 1
R980 30 0 1000
R31 31 32 1
R981 31 0 1000
R32 32 33 1
R982 32 0 1000
R33 33 34 1
R983 33 0 1000
R34 34 35 1
R984 34 0 1000
R35 35 36 1
R985 35 0 1000
R36 36 37 1
R986 36 0 1000
R37 37 38 1
R987 37 0 1000
R38 38 39 1
R988 38 0 1000
R39 39 40 1
R989 39 0 1000
R40 40 41 1
R990 40 0 1000
R41 41 42 1
R991 41 0 1000
R42 42 43 1
R992 42 0 1000
R43 43 44 1
R993 43 0 1000
R44 44 45 1
R994 44 0 1000
R45 45 46 1
R995 45 0 1000
R46 46 47 1
R996 46 0 1000
R47 47 48 1
R997 47 0 1000
R48 48 49 1
R998 48 0 1000
R49 49 50 1
R999 49 0 1000
R50 50 51 1
R1000 50 0 1000
R51 51 52 1
R1001 51 0 1000
R52 52 53 1
R1002 52 0 1000
R53 53 54 1
R1003 53 0 1000
R54 54 55 1
R1004 54 0 1000
R55 55 56 1
R1005 55 0 1000
R56 56 57 1
R1006 56 0 1000
R57 57 58 1
R1007 57 0 1000
R58 58 59 1
R1008 58 0 1000
R59 59 60 1
R1009 59 0 1000
R60 60 61 1
R1010 60 0 1000
R61 61 62 1
R1011 61 0 1000
R62 62 63 1
R1012 62 0 1000
R63 63 64 1
R1013 63 0 1000
R64 64 65 1
R1014 64 0 1000
R65 65 66 1
R1015 65 0 1000
R66 66 67 1
R1016 66 0 1000
R67 67 68 1
R1017 67 0 1000
R68 68 69 1
R1018 68 0 1000
R69 69 70 1
R1019 69 0 1000
R70 70 71 1
R1020 70 0 1000
R71 71 72 1
R1021 71 0 1000
R72 72 73 1
R1022 72 0 1000
R73 73 74 1
R1023 73 0 1000
R74 74 75 1
R1024 74 0 1000
R75 75 76 1
R1025 75 0 1000
R76 76 77 1
R1026 76 0 1000
R77 77 78 1
R1027 77 0 1000
R78 78 79 1
R1028 78 0 1000
R79 79 80 1
R1029 79 0 1000
R80 80 81 1
R1030 80 0 1000
R81 81 82 1
R1031 81 0 1000
R82 82 83 1
R1032 82 0 1000
R83 83 84 1
R1033 83 0 1000
R84 84 85 1
R1034 84 0 1000
R85 85 86 1
R1035 85 0 1000
R86 86 87 1
R1036 86 0 1000
R87 87 88 1
R1037 87 0 1000
R88 88 89 1
R1038 88 0 1000
R89 89 90 1
R1039 89 0 1000
R90 90 91 1
R1040 90 0 1000
R91 91 92 1
R1041 91 0 1000
R92 92 93 1
R1042 92 0 1000
R93 93 94 1
R1043 93 0 1000
R94 94 95 1
R1044 94 0 1000
R95 95 96 1
R1045 95 0 1000
R96 96 97 1
R1046 96 0 1000
R97 97 98 1
R1047 97 0 1000
R98 98 99 1
R1048 98 0 1000
R99 99 100 1
R1049 99 0 1000
R100 100 101 1
R1050 100 0 1000
R101 101 102 1
R1051 101 0 1000
R102 102 103 1
R1052 102 0 1000
R103 103 104 1
R1053 103 0 1000
R104 104 105 1
R1054 104 0 1000
R105 105 106 1
R1055 105 0 1000
R106 106 107 1
R1056 106 0 1000
R107 107 108 1
R1057 107 0 1000
R108 108 109 1
R1058 108 0 1000
R109 109 110 1
R1059 109 0 1000
R110 110 111 1
R1060 110 0 1000
R111 111 112 1
R1061 111 0 1000
R112 112 113 1
R1062 112 0 1000
R113 113 114 1
R1063 113 0 1000
R114 114 115 1
R1064 114 0 1000
R115 115 116 1
R1065 115 0 1000
R116 116 117 1
R1066 116 0 1000
R117 117 118 1
R1067 117 0 1000
R118 118 119 1
R1068 118 0 1000
R119 119 120 1
R1069 119 0 1000
R120 120 121 1
R1070 120 0 1000
R121 121 122 1
R1071 121 0 1000
R122 122 123 1
R1072 122 0 1000
R123 123 124 1
R1073 123 0 1000
R124 124 125 1
R1074 124 0 1000
R125 125 126 1
R1075 125 0 1000
R126 126 127 1
R1076 126 0 1000
R127 127 128 1
R1077 127 0 1000
R128 128 129 1
R1078 128 0 1000
R129 129 130 1
R1079 129 0 1000
R130 130 131 1
R1080 130 0 1000
R131 131 132 1
R1081 131 0 1000
R132 132 133 1
R1082 132 0 1000
R133 133 134 1
R1083 133 0 1000
R134 134 135 1
R1084 134 0 1000
R135 135 136 1
R1085 135 0 1000
R136 136 137 1
R1086 136 0 1000
R137 137 138 1
R1087 137 0 1000
R138 138 139 1
R1088 138 0 1000
R139 139 140 1
R1089 139 0 1000
R140 140 141 1
R1090 140 0 1000
R141 141 142 1
R1091 141 0 1000
R142 142 143 1
R1092 142 0 1000
R143 143 144 1
R1093 143 0 1000
R144 144 145 1
R1094 144 0 1000
R145 145 146 1
R1095 145 0 1000
R146 146 147 1
R1096 146 0 1000
R147 147 148 1
R1097 147 0 1000
R148 148 149 1
R1098 148 0 1000
R149 149 150 1
R1099 149 0 1000
R150 150 151 1
R1100 150 0 1000
R151 151 152 1
R1101 151 0 1000
R152 152 153 1
R1102 152 0 1000
R153 153 154 1
R1103 153 0 1000
R154 154 155 1
R1104 154 0 1000
R155 155 156 1
R1105 155 0 1000
R156 156 157 1
R1106 156 0 1000
R157 157 158 1
R1107 157 0 1000
R158 158 159 1
R1108 158 0 1000
R159 159 160 1
R1109 159 0 1000
R160 160 161 1
R1110 160 0 1000
R161 161 162 1
R1111 161 0 1000
R162 162 163 1
R1112 162 0 1000
R163 163 164 1
R1113 163 0 1000
R164 164 165 1
R1114 164 0 1000
R165 165 166 1
R1115 165 0 1000
R166 166 167 1
R1116 166 0 1000
R167 167 168 1
R1117 167 0 1000
R168 168 169 1
R1118 168 0 1000
R169 169 170 1
R1119 169 0 1000
R170 170 171 1
R1120 170 0 1000
R171 171 172 1
R1121 171 0 1000
R172 172 173 1
R1122 172 0 1000
R173 173 174 1
R1123 173 0 1000
R174 174 175 1
R1124 174 0 1000
R175 175 176 1
R1125 175 0 1000
R176 176 177 1
R1126 176 0 1000
R177 177 178 1
R1127 177 0 1000
R178 178 179 1
R1128 178 0 1000
R179 179 180 1
R1129 179 0 1000
R180 180 181 1
R1130 180 0 1000
R181 181 182 1
R1131 181 0 1000
R182 182 183 1
R1132 182 0 1000
R183 183 184 1
R1133 183 0 1000
R184 184 185 1
R1134 184 0 1000
R185 185 186 1
R1135 185 0 1000
R186 186 187 1
R1136 186 0 1000
R187 187 188 1
R1137 187 0 1000
R188 188 189 1
R1138 188 0 1000
R189 189 190 1
R1139 189 0 1000
R190 190 191 1
R1140 190 0 1000
R191 191 192 1
R1141 191 0 1000
R192 192 193 1
R1142 192 0 1000
R193 193 194 1
R1143 193 0 1000
R194 194 195 1
R1144 194 0 1000
R195 195 196 1
R1145 195 0 1000
R196 196 197 1
R1146 196 0 1000
R197 197 198 1
R1147 197 0 1000
R198 198 199 1
R1148 198 0 1000
R199 199 200 1
R1149 199 0 1000
R200 200 201 1
R1150 200 0 1000
R201 201 202 1
R1151 201 0 1000
R202 202 203 1
R1152 202 0 1000
R203 203 204 1
R1153 203 0 1000
R204 204 205 1
R1154 204 0 1000
R205 205 206 1
R1155 205 0 1000
R206 206 207 1
R1156 206 0 1000
R207 207 208 1
R1157 207 0 1000
R208 208 209 1
R1158 208 0 1000
R209 209 210 1
R1159 209 0 1000
R210 210 211 1
R1160 210 0 1000
R211 211 212 1
R1161 211 0 1000
R212 212 213 1
R1162 212 0 1000
R213 213 214 1
R1163 213 0 1000
R214 214 215 1
R1164 214 0 1000
R215 215 216 1
R1165 215 0 1000
R216 216 217 1
R1166 216 0 1000
R217 217 218 1
R1167 217 0 1000
R218 218 219 1
R1168 218 0 1000
R219 219 220 1
R1169 219 0 1000
R220 220 221 1
R1170 220 0 1000
R221 221 222 1
R1171 221 0 1000
R222 222 223 1
R1172 222 0 1000
R223 223 224 1
R1173 223 0 1000
R224 224 225 1
R1174 224 0 1000
R225 225 226 1
R1175 225 0 1000
R226 226 227 1
R1176 226 0 1000
R227 227 228 1
R1177 227 0 1000
R228 228 229 1
R1178 228 0 1000
R229 229 230 1
R1179 229 0 1000
R230 230 231 1
R1180 230 0 1000
R231 231 232 1
R1181 231 0 1000
R232 232 233 1
R1182 232 0 1000
R233 233 234 1
R1183 233 0 1000
R234 234 235 1
R1184 234 0 1000
R235 235 236 1
R1185 235 0 1000
R236 236 237 1
R1186 236 0 1000
R237 237 238 1
R1187 237 0 1000
R238 238 239 1
R1188 238 0 1000
R239 239 240 1
R1189 239 0 1000
R240 240 241 1
R1190 240 0 1000
R241 241 242 1
R1191 241 0 1000
R242 242 243 1
R1192 242 0 1000
R243 243 244 1
R1193 243 0 1000
R244 244 245 1
R1194 244 0 1000
R245 245 246 1
R1195 245 0 1000
R246 246 247 1
R1196 246 0 1000
R247 247 248 1
R1197 247 0 1000
R248 248 249 1
R1198 248 0 1000
R249 249 250 1
R1199 249 0 1000
R250 250 251 1
R1200 250 0 1000
R251 251 252 1
R1201 251 0 1000
R252 252 253 1
R1202 252 0 1000
R253 253 254 1
R1203 253 0 1000
R254 254 255 1
R1204 254 0 1000
R255 255 256 1
R1205 255 0 1000
R256 256 257 1
R1206 256 0 1000
R257 257 258 1
R1207 257 0 1000
R258 258 259 1
R1208 258 0 1000
R259 259 260 1
R1209 259 0 1000
R260 260 261 1
R1210 260 0 1000
R261 261 262 1
R1211 261 0 1000
R262 262 263 1
R1212 262 0 1000
R263 263 264 1
R1213 263 0 1000
R264 264 265 1
R1214 264 0 1000
R265 265 266 1
R1215 265 0 1000
R266 266 267 1
R1216 266 0 1000
R267 267 268 1
R1217 267 0 1000
R268 268 269 1
R1218 268 0 1000
R269 269 270 1
R1219 269 0 1000
R270 270 271 1
R1220 270 0 1000
R271 271 272 1
R1221 271 0 1000
R272 272 273 1
R1222 272 0 1000
R273 273 274 1
R1223 273 0 1000
R274 274 275 1
R1224 274 0 1000
R275 275 276 1
R1225 275 0 1000
R276 276 277 1
R1226 276 0 1000
R277 277 278 1
R1227 277 0 1000
R278 278 279 1
R1228 278 0 1000
R279 279 280 1
R1229 279 0 1000
R280 280 281 1
R1230 280 0 1000
R281 281 282 1
R1231 281 0 1000
R282 282 283 1
R1232 282 0 1000
R283 283 284 1
R1233 283 0 1000
R284 284 285 1
R1234 284 0 1000
R285 285 286 1
R1235 285 0 1000
R286 286 287 1
R1236 286 0 1000
R287 287 288 1
R1237 287 0 1000
R288 288 289 1
R1238 288 0 1000
R289 289 290 1
R1239 289 0 1000
R290 290 291 1
R1240 290 0 1000
R291 291 292 1
R1241 291 0 1000
R292 292 293 1
R1242 292 0 1000
R293 293 294 1
R1243 293 0 1000
R294 294 295 1
R1244 294 0 1000
R295 295 296 1
R1245 295 0 1000
R296 296 297 1
R1246 296 0 1000
R297 297 298 1
R1247 297 0 1000
R298 298 299 1
R1248 298 0 1000
R299 299 300 1
R1249 299 0 1000
R300 300 301 1
R1250 300 0 1000
R301 301 302 1
R1251 301 0 1000
R302 302 303 1
R1252 302 0 1000
R303 303 304 1
R1253 303 0 1000
R304 304 305 1
R1254 304 0 1000
R305 305 306 1
R1255 305 0 1000
R306 306 307 1
R1256 306 0 1000
R307 307 308 1
R1257 307 0 1000
R308 308 309 1
R1258 308 0 1000
R309 309 310 1
R1259 309 0 1000
R310 310 311 1
R1260 310 0 1000
R311 311 312 1
R1261 311 0 1000
R312 312 313 1
R1262 312 0 1000
R313 313 314 1
R1263 313 0 1000
R314 314 315 1
R1264 314 0 1000
R315 315 316 1
R1265 315 0 1000
R316 316 317 1
R1266 316 0 1000
R317 317 318 1
R1267 317 0 1000
R318 318 319 1
R1268 318 0 1000
R319 319 320 1
R1269 319 0 1000
R320 320 321 1
R1270 320 0 1000
R321 321 322 1
R1271 321 0 1000
R322 322 323 1
R1272 322 0 1000
R323 323 324 1
R1273 323 0 1000
R324 324 325 1
R1274 324 0 1000
R325 325 326 1
R1275 325 0 1000
R326 326 327 1
R1276 326 0 1000
R327 327 328 1
R1277 327 0 1000
R328 328 329 1
R1278 328 0 1000
R329 329 330 1
R1279 329 0 1000
R330 330 331 1
R1280 330 0 1000
R331 331 332 1
R1281 331 0 1000
R332 332 333 1
R1282 332 0 1000
R333 333 334 1
R1283 333 0 1000
R334 334 335 1
R1284 334 0 1000
R335 335 336 1
R1285 335 0 1000
R336 336 337 1
R1286 336 0 1000
R337 337 338 1
R1287 337 0 1000
R338 338 339 1
R1288 338 0 1000
R339 339 340 1
R1289 339 0 1000
R340 340 341 1
R1290 340 0 1000
R341 341 342 1
R1291 341 0 1000
R342 342 343 1
R1292 342 0 1000
R343 343 344 1
R1293 343 0 1000
R344 344 345 1
R1294 344 0 1000
R345 345 346 1
R1295 345 0 1000
R346 346 347 1
R1296 346 0 1000
R347 347 348 1
R1297 347 0 1000
R348 348 349 1
R1298 348 0 1000
R349 349 350 1
R1299 349 0 1000
R350 350 351 1
R1300 350 0 1000
R351 351 352 1
R1301 351 0 1000
R352 352 353 1
R1302 352 0 1000
R353 353 354 1
R1303 353 0 1000
R354 354 355 1
R1304 354 0 1000
R355 355 356 1
R1305 355 0 1000
R356 356 357 1
R1306 356 0 1000
R357 357 358 1
R1307 357 0 1000
R358 358 359 1
R1308 358 0 1000
R359 359 360 1
R1309 359 0 1000
R360 360 361 1
R1310 360 0 1000
R361 361 362 1
R1311 361 0 1000
R362 362 363 1
R1312 362 0 1000
R363 363 364 1
R1313 363 0 1000
R364 364 365 1
R1314 364 0 1000
R365 365 366 1
R1315 365 0 1000
R366 366 367 1
R1316 366 0 1000
R367 367 368 1
R1317 367 0 1000
R368 368 369 1
R1318 368 0 1000
R369 369 370 1
R1319 369 0 1000
R370 370 371 1
R1320 370 0 1000
R371 371 372 1
R1321 371 0 1000
R372 372 373 1
R1322 372 0 1000
R373 373 374 1
R1323 373 0 1000
R374 374 375 1
R1324 374 0 1000
R375 375 376 1
R1325 375 0 1000
R376 376 377 1
R1326 376 0 1000
R377 377 378 1
R1327 377 0 1000
R378 378 379 1
R1328 378 0 1000
R379 379 380 1
R1329 379 0 1000
R380 380 381 1
R1330 380 0 1000
R381 381 382 1
R1331 381 0 1000
R382 382 383 1
R1332 382 0 1000
R383 383 384 1
R1333 383 0 1000
R384 384 385 1
R1334 384 0 1000
R385 385 386 1
R1335 385 0 1000
R386 386 387 1
R1336 386 0 1000
R387 387 388 1
R1337 387 0 1000
R388 388 389 1
R1338 388 0 1000
R389 389 390 1
R1339 389 0 1000
R390 390 391 1
R1340 390 0 1000
R391 391 392 1
R1341 391 0 1000
R392 392 393 1
R1342 392 0 1000
R393 393 394 1
R1343 393 0 1000
R394 394 395 1
R1344 394 0 1000
R395 395 396 1
R1345 395 0 1000
R396 396 397 1
R1346 396 0 1000
R397 397 398 1
R1347 397 0 1000
R398 398 399 1
R1348 398 0 1000
R399 399 400 1
R1349 399 0 1000
R400 400 401 1
R1350 400 0 1000
R401 401 402 1
R1351 401 0 1000
R402 402 403 1
R1352 402 0 1000
R403 403 404 1
R1353 403 0 1000
R404 404 405 1
R1354 404 0 1000
R405 405 406 1
R1355 405 0 1000
R406 406 407 1
R1356 406 0 1000
R407 407 408 1
R1357 407 0 1000
R408 408 409 1
R1358 408 0 1000
R409 409 410 1
R1359 409 0 1000
R410 410 411 1
R1360 410 0 1000
R411 411 412 1
R1361 411 0 1000
R412 412 413 1
R1362 412 0 1000
R413 413 414 1
R1363 413 0 1000
R414 414 415 1
R1364 414 0 1000
R415 415 416 1
R1365 415 0 1000
R416 416 417 1
R1366 416 0 1000
R417 417 418 1
R1367 417 0 1000
R418 418 419 1
R1368 418 0 1000
R419 419 420 1
R1369 419 0 1000
R420 420 421 1
R1370 420 0 1000
R421 421 422 1
R1371 421 0 1000
R422 422 423 1
R1372 422 0 1000
R423 423 424 1
R1373 423 0 1000
R424 424 425 1
R1374 424 0 1000
R425 425 426 1
R1375 425 0 1000
R426 426 427 1
R1376 426 0 1000
R427 427 428 1
R1377 427 0 1000
R428 428 429 1
R1378 428 0 1000
R429 429 430 1
R1379 429 0 1000
R430 430 431 1
R1380 430 0 1000
R431 431 432 1
R1381 431 0 1000
R432 432 433 1
R1382 432 0 1000
R433 433 434 1
R1383 433 0 1000
R434 434 435 1
R1384 434 0 1000
R435 435 436 1
R1385 435 0 1000
R436 436 437 1
R1386 436 0 1000
R437 437 438 1
R1387 437 0 1000
R438 438 439 1
R1388 438 0 1000
R439 439 440 1
R1389 439 0 1000
R440 440 441 1
R1390 440 0 1000
R441 441 442 1
R1391 441 0 1000
R442 442 443 1
R1392 442 0 1000
R443 443 444 1
R1393 443 0 1000
R444 444 445 1
R1394 444 0 1000
R445 445 446 1
R1395 445 0 1000
R446 446 447 1
R1396 446 0 1000
R447 447 448 1
R1397 447 0 1000
R448 448 449 1
R1398 448 0 1000
R449 449 450 1
R1399 449 0 1000
R450 450 451 1
R1400 450 0 1000
R451 451 452 1
R1401 451 0 1000
R452 452 453 1
R1402 452 0 1000
R453 453 454 1
R1403 453 0 1000
R454 454 455 1
R1404 454 0 1000
R455 455 456 1
R1405 455 0 1000
R456 456 457 1
R1406 456 0 1000
R457 457 458 1
R1407 457 0 1000
R458 458 459 1
R1408 458 0 1000
R459 459 460 1
R1409 459 0 1000
R460 460 461 1
R1410 460 0 1000
R461 461 462 1
R1411 461 0 1000
R462 462 463 1
R1412 462 0 1000
R463 463 464 1
R1413 463 0 1000
R464 464 465 1
R1414 464 0 1000
R465 465 466 1
R1415 465 0 1000
R466 466 467 1
R1416 466 0 1000
R467 467 468 1
R1417 467 0 1000
R468 468 469 1
R1418 468 0 1000
R469 469 470 1
R1419 469 0 1000
R470 470 471 1
R1420 470 0 1000
R471 471 472 1
R1421 471 0 1000
R472 472 473 1
R1422 472 0 1000
R473 473 474 1
R1423 473 0 1000
R474 474 475 1
R1424 474 0 1000
R475 475 476 1
R1425 475 0 1000
R476 476 477 1
R1426 476 0 1000
R477 477 478 1
R1427 477 0 1000
R478 478 479 1
R1428 478 0 1000
R479 479 480 1
R1429 479 0 1000
R480 480 481 1
R1430 480 0 1000
R481 481 482 1
R1431 481 0 1000
R482 482 483 1
R1432 482 0 1000
R483 483 484 1
R1433 483 0 1000
R484 484 485 1
R1434 484 0 1000
R485 485 486 1
R1435 485 0 1000
R486 486 487 1
R1436 486 0 1000
R487 487 488 1
R1437 487 0 1000
R488 488 489 1
R1438 488 0 1000
R489 489 490 1
R1439 489 0 1000
R490 490 491 1
R1440 490 0 1000
R491 491 492 1
R1441 491 0 1000
R492 492 493 1
R1442 492 0 1000
R493 493 494 1
R1443 493 0 1000
R494 494 495 1
R1444 494 0 1000
R495 495 496 1
R1445 495 0 1000
R496 496 497 1
R1446 496 0 1000
R497 497 498 1
R1447 497 0 1000
R498 498 499 1
R1448 498 0 1000
R499 499 500 1
R1449 499 0 1000
R500 500 501 1
R1450 500 0 1000
R501 501 502 1
R1451 501 0 1000
R502 502 503 1
R1452 502 0 1000
R503 503 504 1
R1453 503 0 1000
R504 504 505 1
R1454 504 0 1000
R505 505 506 1
R1455 505 0 1000
R506 506 507 1
R1456 506 0 1000
R507 507 508 1
R1457 507 0 1000
R508 508 509 1
R1458 508 0 1000
R509 509 510 1
R1459 509 0 1000
R510 510 511 1
R1460 510 0 1000
R511 511 512 1
R1461 511 0 1000
R512 512 513 1
R1462 512 0 1000
R513 513 514 1
R1463 513 0 1000
R514 514 515 1
R1464 514 0 1000
R515 515 516 1
R1465 515 0 1000
R516 516 517 1
R1466 516 0 1000
R517 517 518 1
R1467 517 0 1000
R518 518 519 1
R1468 518 0 1000
R519 519 520 1
R1469 519 0 1000
R520 520 521 1
R1470 520 0 1000
R521 521 522 1
R1471 521 0 1000
R522 522 523 1
R1472 522 0 1000
R523 523 524 1
R1473 523 0 1000
R524 524 525 1
R1474 524 0 1000
R525 525 526 1
R1475 525 0 1000
R526 526 527 1
R1476 526 0 1000
R527 527 528 1
R1477 527 0 1000
R528 528 529 1
R1478 528 0 1000
R529 529 530 1
R1479 529 0 1000
R530 530 531 1
R1480 530 0 1000
R531 531 532 1
R1481 531 0 1000
R532 532 533 1
R1482 532 0 1000
R533 533 534 1
R1483 533 0 1000
R534 534 535 1
R1484 534 0 1000
R535 535 536 1
R1485 535 0 1000
R536 536 537 1
R1486 536 0 1000
R537 537 538 1
R1487 537 0 1000
R538 538 539 1
R1488 538 0 1000
R539 539 540 1
R1489 539 0 1000
R540 540 541 1
R1490 540 0 1000
R541 541 542 1
R1491 541 0 1000
R542 542 543 1
R1492 542 0 1000
R543 543 544 1
R1493 543 0 1000
R544 544 545 1
R1494 544 0 1000
R545 545 546 1
R1495 545 0 1000
R546 546 547 1
R1496 546 0 1000
R547 547 548 1
R1497 547 0 1000
R548 548 549 1
R1498 548 0 1000
R549 549 550 1
R1499 549 0 1000
R550 550 551 1
R1500 550 0 1000
R551 551 552 1
R1501 551 0 1000
R552 552 553 1
R1502 552 0 1000
R553 553 554 1
R1503 553 0 1000
R554 554 555 1
R1504 554 0 1000
R555 555 556 1
R1505 555 0 1000
R556 556 557 1
R1506 556 0 1000
R557 557 558 1
R1507 557 0 1000
R558 558 559 1
R1508 558 0 1000
R559 559 560 1
R1509 559 0 1000
R560 560 561 1
R1510 560 0 1000
R561 561 562 1
R1511 561 0 1000
R562 562 563 1
R1512 562 0 1000
R563 563 564 1
R1513 563 0 1000
R564 564 565 1
R1514 564 0 1000
R565 565 566 1
R1515 565 0 1000
R566 566 567 1
R1516 566 0 1000
R567 567 568 1
R1517 567 0 1000
R568 568 569 1
R1518 568 0 1000
R569 569 570 1
R1519 569 0 1000
R570 570 571 1
R1520 570 0 1000
R571 571 572 1
R1521 571 0 1000
R572 572 573 1
R1522 572 0 1000
R573 573 574 1
R1523 573 0 1000
R574 574 575 1
R1524 574 0 1000
R575 575 576 1
R1525 575 0 1000
R576 576 577 1
R1526 576 0 1000
R577 577 578 1
R1527 577 0 1000
R578 578 579 1
R1528 578 0 1000
R579 579 580 1
R1529 579 0 1000
R580 580 581 1
R1530 580 0 1000
R581 581 582 1
R1531 581 0 1000
R582 582 583 1
R1532 582 0 1000
R583 583 584 1
R1533 583 0 1000
R584 584 585 1
R1534 584 0 1000
R585 585 586 1
R1535 585 0 1000
R586 586 587 1
R1536 586 0 1000
R587 587 588 1
R1537 587 0 1000
R588 588 589 1
R1538 588 0 1000
R589 589 590 1
R1539 589 0 1000
R590 590 591 1
R1540 590 0 1000
R591 591 592 1
R1541 591 0 1000
R592 592 593 1
R1542 592 0 1000
R593 593 594 1
R1543 593 0 1000
R594 594 595 1
R1544 594 0 1000
R595 595 596 1
R1545 595 0 1000
R596 596 597 1
R1546 596 0 1000
R597 597 598 1
R1547 597 0 1000
R598 598 599 1
R1548 598 0 1000
R599 599 600 1
R1549 599 0 1000
R600 600 601 1
R1550 600 0 1000
R601 601 602 1
R1551 601 0 1000
R602 602 603 1
R1552 602 0 1000
R603 603 604 1
R1553 603 0 1000
R604 604 605 1
R1554 604 0 1000
R605 605 606 1
R1555 605 0 1000
R606 606 607 1
R1556 606 0 1000
R607 607 608 1
R1557 607 0 1000
R608 608 609 1
R1558 608 0 1000
R609 609 610 1
R1559 609 0 1000
R610 610 611 1
R1560 610 0 1000
R611 611 612 1
R1561 611 0 1000
R612 612 613 1
R1562 612 0 1000
R613 613 614 1
R1563 613 0 1000
R614 614 615 1
R1564 614 0 1000
R615 615 616 1
R1565 615 0 1000
R616 616 617 1
R1566 616 0 1000
R617 617 618 1
R1567 617 0 1000
R618 618 619 1
R1568 618 0 1000
R619 619 620 1
R1569 619 0 1000
R620 620 621 1
R1570 620 0 1000
R621 621 622 1
R1571 621 0 1000
R622 622 623 1
R1572 622 0 1000
R623 623 624 1
R1573 623 0 1000
R624 624 625 1
R1574 624 0 1000
R625 625 626 1
R1575 625 0 1000
R626 626 627 1
R1576 626 0 1000
R627 627 628 1
R1577 627 0 1000
R628 628 629 1
R1578 628 0 1000
R629 629 630 1
R1579 629 0 1000
R630 630 631 1
R1580 630 0 1000
R631 631 632 1
R1581 631 0 1000
R632 632 633 1
R1582 632 0 1000
R633 633 634 1
R1583 633 0 1000
R634 634 635 1
R1584 634 0 1000
R635 635 636 1
R1585 635 0 1000
R636 636 637 1
R1586 636 0 1000
R637 637 638 1
R1587 637 0 1000
R638 638 639 1
R1588 638 0 1000
R639 639 640 1
R1589 639 0 1000
R640 640 641 1
R1590 640 0 1000
R641 641 642 1
R1591 641 0 1000
R642 642 643 1
R1592 642 0 1000
R643 643 644 1
R1593 643 0 1000
R644 644 645 1
R1594 644 0 1000
R645 645 646 1
R1595 645 0 1000
R646 646 647 1
R1596 646 0 1000
R647 647 648 1
R1597 647 0 1000
R648 648 649 1
R1598 648 0 1000
R649 649 650 1
R1599 649 0 1000
R650 650 651 1
R1600 650 0 1000
R651 651 652 1
R1601 651 0 1000
R652 652 653 1
R1602 652 0 1000
R653 653 654 1
R1603 653 0 1000
R654 654 655 1
R1604 654 0 1000
R655 655 656 1
R1605 655 0 1000
R656 656 657 1
R1606 656 0 1000
R657 657 658 1
R1607 657 0 1000
R658 658 659 1
R1608 658 0 1000
R659 659 660 1
R1609 659 0 1000
R660 660 661 1
R1610 660 0 1000
R661 661 662 1
R1611 661 0 1000
R662 662 663 1
R1612 662 0 1000
R663 663 664 1
R1613 663 0 1000
R664 664 665 1
R1614 664 0 1000
R665 665 666 1
R1615 665 0 1000
R666 666 667 1
R1616 666 0 1000
R667 667 668 1
R1617 667 0 1000
R668 668 669 1
R1618 668 0 1000
R669 669 670 1
R1619 669 0 1000
R670 670 671 1
R1620 670 0 1000
R671 671 672 1
R1621 671 0 1000
R672 672 673 1
R1622 672 0 1000
R673 673 674 1
R1623 673 0 1000
R674 674 675 1
R1624 674 0 1000
R675 675 676 1
R1625 675 0 1000
R676 676 677 1
R1626 676 0 1000
R677 677 678 1
R1627 677 0 1000
R678 678 679 1
R1628 678 0 1000
R679 679 680 1
R1629 679 0 1000
R680 680 681 1
R1630 680 0 1000
R681 681 682 1
R1631 681 0 1000
R682 682 683 1
R1632 682 0 1000
R683 683 684 1
R1633 683 0 1000
R684 684 685 1
R1634 684 0 1000
R685 685 686 1
R1635 685 0 1000
R686 686 687 1
R1636 686 0 1000
R687 687 688 1
R1637 687 0 1000
R688 688 689 1
R1638 688 0 1000
R689 689 690 1
R1639 689 0 1000
R690 690 691 1
R1640 690 0 1000
R691 691 692 1
R1641 691 0 1000
R692 692 693 1
R1642 692 0 1000
R693 693 694 1
R1643 693 0 1000
R694 694 695 1
R1644 694 0 1000
R695 695 696 1
R1645 695 0 1000
R696 696 697 1
R1646 696 0 1000
R697 697 698 1
R1647 697 0 1000
R698 698 699 1
R1648 698 0 1000
R699 699 700 1
R1649 699 0 1000
R700 700 701 1
R1650 700 0 1000
R701 701 702 1
R1651 701 0 1000
R702 702 703 1
R1652 702 0 1000
R703 703 704 1
R1653 703 0 1000
R704 704 705 1
R1654 704 0 1000
R705 705 706 1
R1655 705 0 1000
R706 706 707 1
R1656 706 0 1000
R707 707 708 1
R1657 707 0 1000
R708 708 709 1
R1658 708 0 1000
R709 709 710 1
R1659 709 0 1000
R710 710 711 1
R1660 710 0 1000
R711 711 712 1
R1661 711 0 1000
R712 712 713 1
R1662 712 0 1000
R713 713 714 1
R1663 713 0 1000
R714 714 715 1
R1664 714 0 1000
R715 715 716 1
R1665 715 0 1000
R716 716 717 1
R1666 716 0 1000
R717 717 718 1
R1667 717 0 1000
R718 718 719 1
R1668 718 0 1000
R719 719 720 1
R1669 719 0 1000
R720 720 721 1
R1670 720 0 1000
R721 721 722 1
R1671 721 0 1000
R722 722 723 1
R1672 722 0 1000
R723 723 724 1
R1673 723 0 1000
R724 724 725 1
R1674 724 0 1000
R725 725 726 1
R1675 725 0 1000
R726 726 727 1
R1676 726 0 1000
R727 727 728 1
R1677 727 0 1000
R728 728 729 1
R1678 728 0 1000
R729 729 730 1
R1679 729 0 1000
R730 730 731 1
R1680 730 0 1000
R731 731 732 1
R1681 731 0 1000
R732 732 733 1
R1682 732 0 1000
R733 733 734 1
R1683 733 0 1000
R734 734 735 1
R1684 734 0 1000
R735 735 736 1
R1685 735 0 1000
R736 736 737 1
R1686 736 0 1000
R737 737 738 1
R1687 737 0 1000
R738 738 739 1
R1688 738 0 1000
R739 739 740 1
R1689 739 0 1000
R740 740 741 1
R1690 740 0 1000
R741 741 742 1
R1691 741 0 1000
R742 742 743 1
R1692 742 0 1000
R743 743 744 1
R1693 743 0 1000
R744 744 745 1
R1694 744 0 1000
R745 745 746 1
R1695 745 0 1000
R746 746 747 1
R1696 746 0 1000
R747 747 748 1
R1697 747 0 1000
R748 748 749 1
R1698 748 0 1000
R749 749 750 1
R1699 749 0 1000
R750 750 751 1
R1700 750 0 1000
R751 751 752 1
R1701 751 0 1000
R752 752 753 1
R1702 752 0 1000
R753 753 754 1
R1703 753 0 1000
R754 754 755 1
R1704 754 0 1000
R755 755 756 1
R1705 755 0 1000
R756 756 757 1
R1706 756 0 1000
R757 757 758 1
R1707 757 0 1000
R758 758 759 1
R1708 758 0 1000
R759 759 760 1
R1709 759 0 1000
R760 760 761 1
R1710 760 0 1000
R761 761 762 1
R1711 761 0 1000
R762 762 763 1
R1712 762 0 1000
R763 763 764 1
R1713 763 0 1000
R764 764 765 1
R1714 764 0 1000
R765 765 766 1
R1715 765 0 1000
R766 766 767 1
R1716 766 0 1000
R767 767 768 1
R1717 767 0 1000
R768 768 769 1
R1718 768 0 1000
R769 769 770 1
R1719 769 0 1000
R770 770 771 1
R1720 770 0 1000
R771 771 772 1
R1721 771 0 1000
R772 772 773 1
R1722 772 0 1000
R773 773 774 1
R1723 773 0 1000
R774 774 775 1
R1724 774 0 1000
R775 775 776 1
R1725 775 0 1000
R776 776 777 1
R1726 776 0 1000
R777 777 778 1
R1727 777 0 1000
R778 778 779 1
R1728 778 0 1000
R779 779 780 1
R1729 779 0 1000
R780 780 781 1
R1730 780 0 1000
R781 781 782 1
R1731 781 0 1000
R782 782 783 1
R1732 782 0 1000
R783 783 784 1
R1733 783 0 1000
R784 784 785 1
R1734 784 0 1000
R785 785 786 1
R1735 785 0 1000
R786 786 787 1
R1736 786 0 1000
R787 787 788 1
R1737 787 0 1000
R788 788 789 1
R1738 788 0 1000
R789 789 790 1
R1739 789 0 1000
R790 790 791 1
R1740 790 0 1000
R791 791 792 1
R1741 791 0 1000
R792 792 793 1
R1742 792 0 1000
R793 793 794 1
R1743 793 0 1000
R794 794 795 1
R1744 794 0 1000
R795 795 796 1
R1745 795 0 1000
R796 796 797 1
R1746 796 0 1000
R797 797 798 1
R1747 797 0 1000
R798 798 799 1
R1748 798 0 1000
R799 799 800 1
R1749 799 0 1000
R800 800 801 1
R1750 800 0 1000
R801 801 802 1
R1751 801 0 1000
R802 802 803 1
R1752 802 0 1000
R803 803 804 1
R1753 803 0 1000
R804 804 805 1
R1754 804 0 1000
R805 805 806 1
R1755 805 0 1000
R806 806 807 1
R1756 806 0 1000
R807 807 808 1
R1757 807 0 1000
R808 808 809 1
R1758 808 0 1000
R809 809 810 1
R1759 809 0 1000
R810 810 811 1
R1760 810 0 1000
R811 811 812 1
R1761 811 0 1000
R812 812 813 1
R1762 812 0 1000
R813 813 814 1
R1763 813 0 1000
R814 814 815 1
R1764 814 0 1000
R815 815 816 1
R1765 815 0 1000
R816 816 817 1
R1766 816 0 1000
R817 817 818 1
R1767 817 0 1000
R818 818 819 1
R1768 818 0 1000
R819 819 820 1
R1769 819 0 1000
R820 820 821 1
R1770 820 0 1000
R821 821 822 1
R1771 821 0 1000
R822 822 823 1
R1772 822 0 1000
R823 823 824 1
R1773 823 0 1000
R824 824 825 1
R1774 824 0 1000
R825 825 826 1
R1775 825 0 1000
R826 826 827 1
R1776 826 0 1000
R827 827 828 1
R1777 827 0 1000
R828 828 829 1
R1778 828 0 1000
R829 829 830 1
R1779 829 0 1000
R830 830 831 1
R1780 830 0 1000
R831 831 832 1
R1781 831 0 1000
R832 832 833 1
R1782 832 0 1000
R833 833 834 1
R1783 833 0 1000
R834 834 835 1
R1784 834 0 1000
R835 835 836 1
R1785 835 0 1000
R836 836 837 1
R1786 836 0 1000
R837 837 838 1
R1787 837 0 1000
R838 838 839 1
R1788 838 0 1000
R839 839 840 1
R1789 839 0 1000
R840 840 841 1
R1790 840 0 1000
R841 841 842 1
R1791 841 0 1000
R842 842 843 1
R1792 842 0 1000
R843 843 844 1
R1793 843 0 1000
R844 844 845 1
R1794 844 0 1000
R845 845 846 1
R1795 845 0 1000
R846 846 847 1
R1796 846 0 1000
R847 847 848 1
R1797 847 0 1000
R848 848 849 1
R1798 848 0 1000
R849 849 850 1
R1799 849 0 1000
R850 850 851 1
R1800 850 0 1000
R851 851 852 1
R1801 851 0 1000
R852 852 853 1
R1802 852 0 1000
R853 853 854 1
R1803 853 0 1000
R854 854 855 1
R1804 854 0 1000
R855 855 856 1
R1805 855 0 1000
R856 856 857 1
R1806 856 0 1000
R857 857 858 1
R1807 857 0 1000
R858 858 859 1
R1808 858 0 1000
R859 859 860 1
R1809 859 0 1000
R860 860 861 1
R1810 860 0 1000
R861 861 862 1
R1811 861 0 1000
R862 862 863 1
R1812 862 0 1000
R863 863 864 1
R1813 863 0 1000
R864 864 865 1
R1814 864 0 1000
R865 865 866 1
R1815 865 0 1000
R866 866 867 1
R1816 866 0 1000
R867 867 868 1
R1817 867 0 1000
R868 868 869 1
R1818 868 0 1000
R869 869 870 1
R1819 869 0 1000
R870 870 871 1
R1820 870 0 1000
R871 871 872 1
R1821 871 0 1000
R872 872 873 1
R1822 872 0 1000
R873 873 874 1
R1823 873 0 1000
R874 874 875 1
R1824 874 0 1000
R875 875 876 1
R1825 875 0 1000
R876 876 877 1
R1826 876 0 1000
R877 877 878 1
R1827 877 0 1000
R878 878 879 1
R1828 878 0 1000
R879 879 880 1
R1829 879 0 1000
R880 880 881 1
R1830 880 0 1000
R881 881 882 1
R1831 881 0 1000
R882 882 883 1
R1832 882 0 1000
R883 883 884 1
R1833 883 0 1000
R884 884 885 1
R1834 884 0 1000
R885 885 886 1
R1835 885 0 1000
R886 886 887 1
R1836 886 0 1000
R887 887 888 1
R1837 887 0 1000
R888 888 889 1
R1838 888 0 1000
R889 889 890 1
R1839 889 0 1000
R890 890 891 1
R1840 890 0 1000
R891 891 892 1
R1841 891 0 1000
R892 892 893 1
R1842 892 0 1000
R893 893 894 1
R1843 893 0 1000
R894 894 895 1
R1844 894 0 1000
R895 895 896 1
R1845 895 0 1000
R896 896 897 1
R1846 896 0 1000
R897 897 898 1
R1847 897 0 1000
R898 898 899 1
R1848 898 0 1000
R899 899 900 1
R1849 899 0 1000
R900 900 901 1
R1850 900 0 1000
R901 901 902 1
R1851 901 0 1000
R902 902 903 1
R1852 902 0 1000
R903 903 904 1
R1853 903 0 1000
R904 904 905 1
R1854 904 0 1000
R905 905 906 1
R1855 905 0 1000
R906 906 907 1
R1856 906 0 1000
R907 907 908 1
R1857 907 0 1000
R908 908 909 1
R1858 908 0 1000
R909 909 910 1
R1859 909 0 1000
R910 910 911 1
R1860 910 0 1000
R911 911 912 1
R1861 911 0 1000
R912 912 913 1
R1862 912 0 1000
R913 913 914 1
R1863 913 0 1000
R914 914 915 1
R1864 914 0 1000
R915 915 916 1
R1865 915 0 1000
R916 916 917 1
R1866 916 0 1000
R917 917 918 1
R1867 917 0 1000
R918 918 919 1
R1868 918 0 1000
R919 919 920 1
R1869 919 0 1000
R920 920 921 1
R1870 920 0 1000
R921 921 922 1
R1871 921 0 1000
R922 922 923 1
R1872 922 0 1000
R923 923 924 1
R1873 923 0 1000
R924 924 925 1
R1874 924 0 1000
R925 925 926 1
R1875 925 0 1000
R926 926 927 1
R1876 926 0 1000
R927 927 928 1
R1877 927 0 1000
R928 928 929 1
R1878 928 0 1000
R929 929 930 1
R1879 929 0 1000
R930 930 931 1
R1880 930 0 1000
R931 931 932 1
R1881 931 0 1000
R932 932 933 1
R1882 932 0 1000
R933 933 934 1
R1883 933 0 1000
R934 934 935 1
R1884 934 0 1000
R935 935 936 1
R1885 935 0 1000
R936 936 937 1
R1886 936 0 1000
R937 937 938 1
R1887 937 0 1000
R938 938 939 1
R1888 938 0 1000
R939 939 940 1
R1889 939 0 1000
R940 940 941 1
R1890 940 0 1000
R941 941 942 1
R1891 941 0 1000
R942 942 943 1
R1892 942 0 1000
R943 943 944 1
R1893 943 0 1000
R944 944 945 1
R1894 944 0 1000
R945 945 946 1
R1895 945 0 1000
R946 946 947 1
R1896 946 0 1000
R947 947 948 1
R1897 947 0 1000
R948 948 949 1
R1898 948 0 1000
R949 949 950 1
R1899 949 0 1000
.tran 0 3 0 0.001
.end
