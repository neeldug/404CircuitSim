*100
V1 1 0 SINE(0 100 1)
R1 1 2 1
R101 1 0 1000
R2 2 3 1
R102 2 0 1000
R3 3 4 1
R103 3 0 1000
R4 4 5 1
R104 4 0 1000
R5 5 6 1
R105 5 0 1000
R6 6 7 1
R106 6 0 1000
R7 7 8 1
R107 7 0 1000
R8 8 9 1
R108 8 0 1000
R9 9 10 1
R109 9 0 1000
R10 10 11 1
R110 10 0 1000
R11 11 12 1
R111 11 0 1000
R12 12 13 1
R112 12 0 1000
R13 13 14 1
R113 13 0 1000
R14 14 15 1
R114 14 0 1000
R15 15 16 1
R115 15 0 1000
R16 16 17 1
R116 16 0 1000
R17 17 18 1
R117 17 0 1000
R18 18 19 1
R118 18 0 1000
R19 19 20 1
R119 19 0 1000
R20 20 21 1
R120 20 0 1000
R21 21 22 1
R121 21 0 1000
R22 22 23 1
R122 22 0 1000
R23 23 24 1
R123 23 0 1000
R24 24 25 1
R124 24 0 1000
R25 25 26 1
R125 25 0 1000
R26 26 27 1
R126 26 0 1000
R27 27 28 1
R127 27 0 1000
R28 28 29 1
R128 28 0 1000
R29 29 30 1
R129 29 0 1000
R30 30 31 1
R130 30 0 1000
R31 31 32 1
R131 31 0 1000
R32 32 33 1
R132 32 0 1000
R33 33 34 1
R133 33 0 1000
R34 34 35 1
R134 34 0 1000
R35 35 36 1
R135 35 0 1000
R36 36 37 1
R136 36 0 1000
R37 37 38 1
R137 37 0 1000
R38 38 39 1
R138 38 0 1000
R39 39 40 1
R139 39 0 1000
R40 40 41 1
R140 40 0 1000
R41 41 42 1
R141 41 0 1000
R42 42 43 1
R142 42 0 1000
R43 43 44 1
R143 43 0 1000
R44 44 45 1
R144 44 0 1000
R45 45 46 1
R145 45 0 1000
R46 46 47 1
R146 46 0 1000
R47 47 48 1
R147 47 0 1000
R48 48 49 1
R148 48 0 1000
R49 49 50 1
R149 49 0 1000
R50 50 51 1
R150 50 0 1000
R51 51 52 1
R151 51 0 1000
R52 52 53 1
R152 52 0 1000
R53 53 54 1
R153 53 0 1000
R54 54 55 1
R154 54 0 1000
R55 55 56 1
R155 55 0 1000
R56 56 57 1
R156 56 0 1000
R57 57 58 1
R157 57 0 1000
R58 58 59 1
R158 58 0 1000
R59 59 60 1
R159 59 0 1000
R60 60 61 1
R160 60 0 1000
R61 61 62 1
R161 61 0 1000
R62 62 63 1
R162 62 0 1000
R63 63 64 1
R163 63 0 1000
R64 64 65 1
R164 64 0 1000
R65 65 66 1
R165 65 0 1000
R66 66 67 1
R166 66 0 1000
R67 67 68 1
R167 67 0 1000
R68 68 69 1
R168 68 0 1000
R69 69 70 1
R169 69 0 1000
R70 70 71 1
R170 70 0 1000
R71 71 72 1
R171 71 0 1000
R72 72 73 1
R172 72 0 1000
R73 73 74 1
R173 73 0 1000
R74 74 75 1
R174 74 0 1000
R75 75 76 1
R175 75 0 1000
R76 76 77 1
R176 76 0 1000
R77 77 78 1
R177 77 0 1000
R78 78 79 1
R178 78 0 1000
R79 79 80 1
R179 79 0 1000
R80 80 81 1
R180 80 0 1000
R81 81 82 1
R181 81 0 1000
R82 82 83 1
R182 82 0 1000
R83 83 84 1
R183 83 0 1000
R84 84 85 1
R184 84 0 1000
R85 85 86 1
R185 85 0 1000
R86 86 87 1
R186 86 0 1000
R87 87 88 1
R187 87 0 1000
R88 88 89 1
R188 88 0 1000
R89 89 90 1
R189 89 0 1000
R90 90 91 1
R190 90 0 1000
R91 91 92 1
R191 91 0 1000
R92 92 93 1
R192 92 0 1000
R93 93 94 1
R193 93 0 1000
R94 94 95 1
R194 94 0 1000
R95 95 96 1
R195 95 0 1000
R96 96 97 1
R196 96 0 1000
R97 97 98 1
R197 97 0 1000
R98 98 99 1
R198 98 0 1000
R99 99 100 1
R199 99 0 1000
.tran 0 3 0 0.001
.end
