*200
V1 1 0 SINE(0 100 1)
R1 1 2 1
R201 1 0 1000
R2 2 3 1
R202 2 0 1000
R3 3 4 1
R203 3 0 1000
R4 4 5 1
R204 4 0 1000
R5 5 6 1
R205 5 0 1000
R6 6 7 1
R206 6 0 1000
R7 7 8 1
R207 7 0 1000
R8 8 9 1
R208 8 0 1000
R9 9 10 1
R209 9 0 1000
R10 10 11 1
R210 10 0 1000
R11 11 12 1
R211 11 0 1000
R12 12 13 1
R212 12 0 1000
R13 13 14 1
R213 13 0 1000
R14 14 15 1
R214 14 0 1000
R15 15 16 1
R215 15 0 1000
R16 16 17 1
R216 16 0 1000
R17 17 18 1
R217 17 0 1000
R18 18 19 1
R218 18 0 1000
R19 19 20 1
R219 19 0 1000
R20 20 21 1
R220 20 0 1000
R21 21 22 1
R221 21 0 1000
R22 22 23 1
R222 22 0 1000
R23 23 24 1
R223 23 0 1000
R24 24 25 1
R224 24 0 1000
R25 25 26 1
R225 25 0 1000
R26 26 27 1
R226 26 0 1000
R27 27 28 1
R227 27 0 1000
R28 28 29 1
R228 28 0 1000
R29 29 30 1
R229 29 0 1000
R30 30 31 1
R230 30 0 1000
R31 31 32 1
R231 31 0 1000
R32 32 33 1
R232 32 0 1000
R33 33 34 1
R233 33 0 1000
R34 34 35 1
R234 34 0 1000
R35 35 36 1
R235 35 0 1000
R36 36 37 1
R236 36 0 1000
R37 37 38 1
R237 37 0 1000
R38 38 39 1
R238 38 0 1000
R39 39 40 1
R239 39 0 1000
R40 40 41 1
R240 40 0 1000
R41 41 42 1
R241 41 0 1000
R42 42 43 1
R242 42 0 1000
R43 43 44 1
R243 43 0 1000
R44 44 45 1
R244 44 0 1000
R45 45 46 1
R245 45 0 1000
R46 46 47 1
R246 46 0 1000
R47 47 48 1
R247 47 0 1000
R48 48 49 1
R248 48 0 1000
R49 49 50 1
R249 49 0 1000
R50 50 51 1
R250 50 0 1000
R51 51 52 1
R251 51 0 1000
R52 52 53 1
R252 52 0 1000
R53 53 54 1
R253 53 0 1000
R54 54 55 1
R254 54 0 1000
R55 55 56 1
R255 55 0 1000
R56 56 57 1
R256 56 0 1000
R57 57 58 1
R257 57 0 1000
R58 58 59 1
R258 58 0 1000
R59 59 60 1
R259 59 0 1000
R60 60 61 1
R260 60 0 1000
R61 61 62 1
R261 61 0 1000
R62 62 63 1
R262 62 0 1000
R63 63 64 1
R263 63 0 1000
R64 64 65 1
R264 64 0 1000
R65 65 66 1
R265 65 0 1000
R66 66 67 1
R266 66 0 1000
R67 67 68 1
R267 67 0 1000
R68 68 69 1
R268 68 0 1000
R69 69 70 1
R269 69 0 1000
R70 70 71 1
R270 70 0 1000
R71 71 72 1
R271 71 0 1000
R72 72 73 1
R272 72 0 1000
R73 73 74 1
R273 73 0 1000
R74 74 75 1
R274 74 0 1000
R75 75 76 1
R275 75 0 1000
R76 76 77 1
R276 76 0 1000
R77 77 78 1
R277 77 0 1000
R78 78 79 1
R278 78 0 1000
R79 79 80 1
R279 79 0 1000
R80 80 81 1
R280 80 0 1000
R81 81 82 1
R281 81 0 1000
R82 82 83 1
R282 82 0 1000
R83 83 84 1
R283 83 0 1000
R84 84 85 1
R284 84 0 1000
R85 85 86 1
R285 85 0 1000
R86 86 87 1
R286 86 0 1000
R87 87 88 1
R287 87 0 1000
R88 88 89 1
R288 88 0 1000
R89 89 90 1
R289 89 0 1000
R90 90 91 1
R290 90 0 1000
R91 91 92 1
R291 91 0 1000
R92 92 93 1
R292 92 0 1000
R93 93 94 1
R293 93 0 1000
R94 94 95 1
R294 94 0 1000
R95 95 96 1
R295 95 0 1000
R96 96 97 1
R296 96 0 1000
R97 97 98 1
R297 97 0 1000
R98 98 99 1
R298 98 0 1000
R99 99 100 1
R299 99 0 1000
R100 100 101 1
R300 100 0 1000
R101 101 102 1
R301 101 0 1000
R102 102 103 1
R302 102 0 1000
R103 103 104 1
R303 103 0 1000
R104 104 105 1
R304 104 0 1000
R105 105 106 1
R305 105 0 1000
R106 106 107 1
R306 106 0 1000
R107 107 108 1
R307 107 0 1000
R108 108 109 1
R308 108 0 1000
R109 109 110 1
R309 109 0 1000
R110 110 111 1
R310 110 0 1000
R111 111 112 1
R311 111 0 1000
R112 112 113 1
R312 112 0 1000
R113 113 114 1
R313 113 0 1000
R114 114 115 1
R314 114 0 1000
R115 115 116 1
R315 115 0 1000
R116 116 117 1
R316 116 0 1000
R117 117 118 1
R317 117 0 1000
R118 118 119 1
R318 118 0 1000
R119 119 120 1
R319 119 0 1000
R120 120 121 1
R320 120 0 1000
R121 121 122 1
R321 121 0 1000
R122 122 123 1
R322 122 0 1000
R123 123 124 1
R323 123 0 1000
R124 124 125 1
R324 124 0 1000
R125 125 126 1
R325 125 0 1000
R126 126 127 1
R326 126 0 1000
R127 127 128 1
R327 127 0 1000
R128 128 129 1
R328 128 0 1000
R129 129 130 1
R329 129 0 1000
R130 130 131 1
R330 130 0 1000
R131 131 132 1
R331 131 0 1000
R132 132 133 1
R332 132 0 1000
R133 133 134 1
R333 133 0 1000
R134 134 135 1
R334 134 0 1000
R135 135 136 1
R335 135 0 1000
R136 136 137 1
R336 136 0 1000
R137 137 138 1
R337 137 0 1000
R138 138 139 1
R338 138 0 1000
R139 139 140 1
R339 139 0 1000
R140 140 141 1
R340 140 0 1000
R141 141 142 1
R341 141 0 1000
R142 142 143 1
R342 142 0 1000
R143 143 144 1
R343 143 0 1000
R144 144 145 1
R344 144 0 1000
R145 145 146 1
R345 145 0 1000
R146 146 147 1
R346 146 0 1000
R147 147 148 1
R347 147 0 1000
R148 148 149 1
R348 148 0 1000
R149 149 150 1
R349 149 0 1000
R150 150 151 1
R350 150 0 1000
R151 151 152 1
R351 151 0 1000
R152 152 153 1
R352 152 0 1000
R153 153 154 1
R353 153 0 1000
R154 154 155 1
R354 154 0 1000
R155 155 156 1
R355 155 0 1000
R156 156 157 1
R356 156 0 1000
R157 157 158 1
R357 157 0 1000
R158 158 159 1
R358 158 0 1000
R159 159 160 1
R359 159 0 1000
R160 160 161 1
R360 160 0 1000
R161 161 162 1
R361 161 0 1000
R162 162 163 1
R362 162 0 1000
R163 163 164 1
R363 163 0 1000
R164 164 165 1
R364 164 0 1000
R165 165 166 1
R365 165 0 1000
R166 166 167 1
R366 166 0 1000
R167 167 168 1
R367 167 0 1000
R168 168 169 1
R368 168 0 1000
R169 169 170 1
R369 169 0 1000
R170 170 171 1
R370 170 0 1000
R171 171 172 1
R371 171 0 1000
R172 172 173 1
R372 172 0 1000
R173 173 174 1
R373 173 0 1000
R174 174 175 1
R374 174 0 1000
R175 175 176 1
R375 175 0 1000
R176 176 177 1
R376 176 0 1000
R177 177 178 1
R377 177 0 1000
R178 178 179 1
R378 178 0 1000
R179 179 180 1
R379 179 0 1000
R180 180 181 1
R380 180 0 1000
R181 181 182 1
R381 181 0 1000
R182 182 183 1
R382 182 0 1000
R183 183 184 1
R383 183 0 1000
R184 184 185 1
R384 184 0 1000
R185 185 186 1
R385 185 0 1000
R186 186 187 1
R386 186 0 1000
R187 187 188 1
R387 187 0 1000
R188 188 189 1
R388 188 0 1000
R189 189 190 1
R389 189 0 1000
R190 190 191 1
R390 190 0 1000
R191 191 192 1
R391 191 0 1000
R192 192 193 1
R392 192 0 1000
R193 193 194 1
R393 193 0 1000
R194 194 195 1
R394 194 0 1000
R195 195 196 1
R395 195 0 1000
R196 196 197 1
R396 196 0 1000
R197 197 198 1
R397 197 0 1000
R198 198 199 1
R398 198 0 1000
R199 199 200 1
R399 199 0 1000
.tran 0 3 0 0.001
.end
