*300
V1 1 0 SINE(0 100 1)
R1 1 2 1
R301 1 0 1000
R2 2 3 1
R302 2 0 1000
R3 3 4 1
R303 3 0 1000
R4 4 5 1
R304 4 0 1000
R5 5 6 1
R305 5 0 1000
R6 6 7 1
R306 6 0 1000
R7 7 8 1
R307 7 0 1000
R8 8 9 1
R308 8 0 1000
R9 9 10 1
R309 9 0 1000
R10 10 11 1
R310 10 0 1000
R11 11 12 1
R311 11 0 1000
R12 12 13 1
R312 12 0 1000
R13 13 14 1
R313 13 0 1000
R14 14 15 1
R314 14 0 1000
R15 15 16 1
R315 15 0 1000
R16 16 17 1
R316 16 0 1000
R17 17 18 1
R317 17 0 1000
R18 18 19 1
R318 18 0 1000
R19 19 20 1
R319 19 0 1000
R20 20 21 1
R320 20 0 1000
R21 21 22 1
R321 21 0 1000
R22 22 23 1
R322 22 0 1000
R23 23 24 1
R323 23 0 1000
R24 24 25 1
R324 24 0 1000
R25 25 26 1
R325 25 0 1000
R26 26 27 1
R326 26 0 1000
R27 27 28 1
R327 27 0 1000
R28 28 29 1
R328 28 0 1000
R29 29 30 1
R329 29 0 1000
R30 30 31 1
R330 30 0 1000
R31 31 32 1
R331 31 0 1000
R32 32 33 1
R332 32 0 1000
R33 33 34 1
R333 33 0 1000
R34 34 35 1
R334 34 0 1000
R35 35 36 1
R335 35 0 1000
R36 36 37 1
R336 36 0 1000
R37 37 38 1
R337 37 0 1000
R38 38 39 1
R338 38 0 1000
R39 39 40 1
R339 39 0 1000
R40 40 41 1
R340 40 0 1000
R41 41 42 1
R341 41 0 1000
R42 42 43 1
R342 42 0 1000
R43 43 44 1
R343 43 0 1000
R44 44 45 1
R344 44 0 1000
R45 45 46 1
R345 45 0 1000
R46 46 47 1
R346 46 0 1000
R47 47 48 1
R347 47 0 1000
R48 48 49 1
R348 48 0 1000
R49 49 50 1
R349 49 0 1000
R50 50 51 1
R350 50 0 1000
R51 51 52 1
R351 51 0 1000
R52 52 53 1
R352 52 0 1000
R53 53 54 1
R353 53 0 1000
R54 54 55 1
R354 54 0 1000
R55 55 56 1
R355 55 0 1000
R56 56 57 1
R356 56 0 1000
R57 57 58 1
R357 57 0 1000
R58 58 59 1
R358 58 0 1000
R59 59 60 1
R359 59 0 1000
R60 60 61 1
R360 60 0 1000
R61 61 62 1
R361 61 0 1000
R62 62 63 1
R362 62 0 1000
R63 63 64 1
R363 63 0 1000
R64 64 65 1
R364 64 0 1000
R65 65 66 1
R365 65 0 1000
R66 66 67 1
R366 66 0 1000
R67 67 68 1
R367 67 0 1000
R68 68 69 1
R368 68 0 1000
R69 69 70 1
R369 69 0 1000
R70 70 71 1
R370 70 0 1000
R71 71 72 1
R371 71 0 1000
R72 72 73 1
R372 72 0 1000
R73 73 74 1
R373 73 0 1000
R74 74 75 1
R374 74 0 1000
R75 75 76 1
R375 75 0 1000
R76 76 77 1
R376 76 0 1000
R77 77 78 1
R377 77 0 1000
R78 78 79 1
R378 78 0 1000
R79 79 80 1
R379 79 0 1000
R80 80 81 1
R380 80 0 1000
R81 81 82 1
R381 81 0 1000
R82 82 83 1
R382 82 0 1000
R83 83 84 1
R383 83 0 1000
R84 84 85 1
R384 84 0 1000
R85 85 86 1
R385 85 0 1000
R86 86 87 1
R386 86 0 1000
R87 87 88 1
R387 87 0 1000
R88 88 89 1
R388 88 0 1000
R89 89 90 1
R389 89 0 1000
R90 90 91 1
R390 90 0 1000
R91 91 92 1
R391 91 0 1000
R92 92 93 1
R392 92 0 1000
R93 93 94 1
R393 93 0 1000
R94 94 95 1
R394 94 0 1000
R95 95 96 1
R395 95 0 1000
R96 96 97 1
R396 96 0 1000
R97 97 98 1
R397 97 0 1000
R98 98 99 1
R398 98 0 1000
R99 99 100 1
R399 99 0 1000
R100 100 101 1
R400 100 0 1000
R101 101 102 1
R401 101 0 1000
R102 102 103 1
R402 102 0 1000
R103 103 104 1
R403 103 0 1000
R104 104 105 1
R404 104 0 1000
R105 105 106 1
R405 105 0 1000
R106 106 107 1
R406 106 0 1000
R107 107 108 1
R407 107 0 1000
R108 108 109 1
R408 108 0 1000
R109 109 110 1
R409 109 0 1000
R110 110 111 1
R410 110 0 1000
R111 111 112 1
R411 111 0 1000
R112 112 113 1
R412 112 0 1000
R113 113 114 1
R413 113 0 1000
R114 114 115 1
R414 114 0 1000
R115 115 116 1
R415 115 0 1000
R116 116 117 1
R416 116 0 1000
R117 117 118 1
R417 117 0 1000
R118 118 119 1
R418 118 0 1000
R119 119 120 1
R419 119 0 1000
R120 120 121 1
R420 120 0 1000
R121 121 122 1
R421 121 0 1000
R122 122 123 1
R422 122 0 1000
R123 123 124 1
R423 123 0 1000
R124 124 125 1
R424 124 0 1000
R125 125 126 1
R425 125 0 1000
R126 126 127 1
R426 126 0 1000
R127 127 128 1
R427 127 0 1000
R128 128 129 1
R428 128 0 1000
R129 129 130 1
R429 129 0 1000
R130 130 131 1
R430 130 0 1000
R131 131 132 1
R431 131 0 1000
R132 132 133 1
R432 132 0 1000
R133 133 134 1
R433 133 0 1000
R134 134 135 1
R434 134 0 1000
R135 135 136 1
R435 135 0 1000
R136 136 137 1
R436 136 0 1000
R137 137 138 1
R437 137 0 1000
R138 138 139 1
R438 138 0 1000
R139 139 140 1
R439 139 0 1000
R140 140 141 1
R440 140 0 1000
R141 141 142 1
R441 141 0 1000
R142 142 143 1
R442 142 0 1000
R143 143 144 1
R443 143 0 1000
R144 144 145 1
R444 144 0 1000
R145 145 146 1
R445 145 0 1000
R146 146 147 1
R446 146 0 1000
R147 147 148 1
R447 147 0 1000
R148 148 149 1
R448 148 0 1000
R149 149 150 1
R449 149 0 1000
R150 150 151 1
R450 150 0 1000
R151 151 152 1
R451 151 0 1000
R152 152 153 1
R452 152 0 1000
R153 153 154 1
R453 153 0 1000
R154 154 155 1
R454 154 0 1000
R155 155 156 1
R455 155 0 1000
R156 156 157 1
R456 156 0 1000
R157 157 158 1
R457 157 0 1000
R158 158 159 1
R458 158 0 1000
R159 159 160 1
R459 159 0 1000
R160 160 161 1
R460 160 0 1000
R161 161 162 1
R461 161 0 1000
R162 162 163 1
R462 162 0 1000
R163 163 164 1
R463 163 0 1000
R164 164 165 1
R464 164 0 1000
R165 165 166 1
R465 165 0 1000
R166 166 167 1
R466 166 0 1000
R167 167 168 1
R467 167 0 1000
R168 168 169 1
R468 168 0 1000
R169 169 170 1
R469 169 0 1000
R170 170 171 1
R470 170 0 1000
R171 171 172 1
R471 171 0 1000
R172 172 173 1
R472 172 0 1000
R173 173 174 1
R473 173 0 1000
R174 174 175 1
R474 174 0 1000
R175 175 176 1
R475 175 0 1000
R176 176 177 1
R476 176 0 1000
R177 177 178 1
R477 177 0 1000
R178 178 179 1
R478 178 0 1000
R179 179 180 1
R479 179 0 1000
R180 180 181 1
R480 180 0 1000
R181 181 182 1
R481 181 0 1000
R182 182 183 1
R482 182 0 1000
R183 183 184 1
R483 183 0 1000
R184 184 185 1
R484 184 0 1000
R185 185 186 1
R485 185 0 1000
R186 186 187 1
R486 186 0 1000
R187 187 188 1
R487 187 0 1000
R188 188 189 1
R488 188 0 1000
R189 189 190 1
R489 189 0 1000
R190 190 191 1
R490 190 0 1000
R191 191 192 1
R491 191 0 1000
R192 192 193 1
R492 192 0 1000
R193 193 194 1
R493 193 0 1000
R194 194 195 1
R494 194 0 1000
R195 195 196 1
R495 195 0 1000
R196 196 197 1
R496 196 0 1000
R197 197 198 1
R497 197 0 1000
R198 198 199 1
R498 198 0 1000
R199 199 200 1
R499 199 0 1000
R200 200 201 1
R500 200 0 1000
R201 201 202 1
R501 201 0 1000
R202 202 203 1
R502 202 0 1000
R203 203 204 1
R503 203 0 1000
R204 204 205 1
R504 204 0 1000
R205 205 206 1
R505 205 0 1000
R206 206 207 1
R506 206 0 1000
R207 207 208 1
R507 207 0 1000
R208 208 209 1
R508 208 0 1000
R209 209 210 1
R509 209 0 1000
R210 210 211 1
R510 210 0 1000
R211 211 212 1
R511 211 0 1000
R212 212 213 1
R512 212 0 1000
R213 213 214 1
R513 213 0 1000
R214 214 215 1
R514 214 0 1000
R215 215 216 1
R515 215 0 1000
R216 216 217 1
R516 216 0 1000
R217 217 218 1
R517 217 0 1000
R218 218 219 1
R518 218 0 1000
R219 219 220 1
R519 219 0 1000
R220 220 221 1
R520 220 0 1000
R221 221 222 1
R521 221 0 1000
R222 222 223 1
R522 222 0 1000
R223 223 224 1
R523 223 0 1000
R224 224 225 1
R524 224 0 1000
R225 225 226 1
R525 225 0 1000
R226 226 227 1
R526 226 0 1000
R227 227 228 1
R527 227 0 1000
R228 228 229 1
R528 228 0 1000
R229 229 230 1
R529 229 0 1000
R230 230 231 1
R530 230 0 1000
R231 231 232 1
R531 231 0 1000
R232 232 233 1
R532 232 0 1000
R233 233 234 1
R533 233 0 1000
R234 234 235 1
R534 234 0 1000
R235 235 236 1
R535 235 0 1000
R236 236 237 1
R536 236 0 1000
R237 237 238 1
R537 237 0 1000
R238 238 239 1
R538 238 0 1000
R239 239 240 1
R539 239 0 1000
R240 240 241 1
R540 240 0 1000
R241 241 242 1
R541 241 0 1000
R242 242 243 1
R542 242 0 1000
R243 243 244 1
R543 243 0 1000
R244 244 245 1
R544 244 0 1000
R245 245 246 1
R545 245 0 1000
R246 246 247 1
R546 246 0 1000
R247 247 248 1
R547 247 0 1000
R248 248 249 1
R548 248 0 1000
R249 249 250 1
R549 249 0 1000
R250 250 251 1
R550 250 0 1000
R251 251 252 1
R551 251 0 1000
R252 252 253 1
R552 252 0 1000
R253 253 254 1
R553 253 0 1000
R254 254 255 1
R554 254 0 1000
R255 255 256 1
R555 255 0 1000
R256 256 257 1
R556 256 0 1000
R257 257 258 1
R557 257 0 1000
R258 258 259 1
R558 258 0 1000
R259 259 260 1
R559 259 0 1000
R260 260 261 1
R560 260 0 1000
R261 261 262 1
R561 261 0 1000
R262 262 263 1
R562 262 0 1000
R263 263 264 1
R563 263 0 1000
R264 264 265 1
R564 264 0 1000
R265 265 266 1
R565 265 0 1000
R266 266 267 1
R566 266 0 1000
R267 267 268 1
R567 267 0 1000
R268 268 269 1
R568 268 0 1000
R269 269 270 1
R569 269 0 1000
R270 270 271 1
R570 270 0 1000
R271 271 272 1
R571 271 0 1000
R272 272 273 1
R572 272 0 1000
R273 273 274 1
R573 273 0 1000
R274 274 275 1
R574 274 0 1000
R275 275 276 1
R575 275 0 1000
R276 276 277 1
R576 276 0 1000
R277 277 278 1
R577 277 0 1000
R278 278 279 1
R578 278 0 1000
R279 279 280 1
R579 279 0 1000
R280 280 281 1
R580 280 0 1000
R281 281 282 1
R581 281 0 1000
R282 282 283 1
R582 282 0 1000
R283 283 284 1
R583 283 0 1000
R284 284 285 1
R584 284 0 1000
R285 285 286 1
R585 285 0 1000
R286 286 287 1
R586 286 0 1000
R287 287 288 1
R587 287 0 1000
R288 288 289 1
R588 288 0 1000
R289 289 290 1
R589 289 0 1000
R290 290 291 1
R590 290 0 1000
R291 291 292 1
R591 291 0 1000
R292 292 293 1
R592 292 0 1000
R293 293 294 1
R593 293 0 1000
R294 294 295 1
R594 294 0 1000
R295 295 296 1
R595 295 0 1000
R296 296 297 1
R596 296 0 1000
R297 297 298 1
R597 297 0 1000
R298 298 299 1
R598 298 0 1000
R299 299 300 1
R599 299 0 1000
.tran 0 3 0 0.001
.end
