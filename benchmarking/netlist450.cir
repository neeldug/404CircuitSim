*450
V1 1 0 SINE(0 100 1)
R1 1 2 1
R451 1 0 1000
R2 2 3 1
R452 2 0 1000
R3 3 4 1
R453 3 0 1000
R4 4 5 1
R454 4 0 1000
R5 5 6 1
R455 5 0 1000
R6 6 7 1
R456 6 0 1000
R7 7 8 1
R457 7 0 1000
R8 8 9 1
R458 8 0 1000
R9 9 10 1
R459 9 0 1000
R10 10 11 1
R460 10 0 1000
R11 11 12 1
R461 11 0 1000
R12 12 13 1
R462 12 0 1000
R13 13 14 1
R463 13 0 1000
R14 14 15 1
R464 14 0 1000
R15 15 16 1
R465 15 0 1000
R16 16 17 1
R466 16 0 1000
R17 17 18 1
R467 17 0 1000
R18 18 19 1
R468 18 0 1000
R19 19 20 1
R469 19 0 1000
R20 20 21 1
R470 20 0 1000
R21 21 22 1
R471 21 0 1000
R22 22 23 1
R472 22 0 1000
R23 23 24 1
R473 23 0 1000
R24 24 25 1
R474 24 0 1000
R25 25 26 1
R475 25 0 1000
R26 26 27 1
R476 26 0 1000
R27 27 28 1
R477 27 0 1000
R28 28 29 1
R478 28 0 1000
R29 29 30 1
R479 29 0 1000
R30 30 31 1
R480 30 0 1000
R31 31 32 1
R481 31 0 1000
R32 32 33 1
R482 32 0 1000
R33 33 34 1
R483 33 0 1000
R34 34 35 1
R484 34 0 1000
R35 35 36 1
R485 35 0 1000
R36 36 37 1
R486 36 0 1000
R37 37 38 1
R487 37 0 1000
R38 38 39 1
R488 38 0 1000
R39 39 40 1
R489 39 0 1000
R40 40 41 1
R490 40 0 1000
R41 41 42 1
R491 41 0 1000
R42 42 43 1
R492 42 0 1000
R43 43 44 1
R493 43 0 1000
R44 44 45 1
R494 44 0 1000
R45 45 46 1
R495 45 0 1000
R46 46 47 1
R496 46 0 1000
R47 47 48 1
R497 47 0 1000
R48 48 49 1
R498 48 0 1000
R49 49 50 1
R499 49 0 1000
R50 50 51 1
R500 50 0 1000
R51 51 52 1
R501 51 0 1000
R52 52 53 1
R502 52 0 1000
R53 53 54 1
R503 53 0 1000
R54 54 55 1
R504 54 0 1000
R55 55 56 1
R505 55 0 1000
R56 56 57 1
R506 56 0 1000
R57 57 58 1
R507 57 0 1000
R58 58 59 1
R508 58 0 1000
R59 59 60 1
R509 59 0 1000
R60 60 61 1
R510 60 0 1000
R61 61 62 1
R511 61 0 1000
R62 62 63 1
R512 62 0 1000
R63 63 64 1
R513 63 0 1000
R64 64 65 1
R514 64 0 1000
R65 65 66 1
R515 65 0 1000
R66 66 67 1
R516 66 0 1000
R67 67 68 1
R517 67 0 1000
R68 68 69 1
R518 68 0 1000
R69 69 70 1
R519 69 0 1000
R70 70 71 1
R520 70 0 1000
R71 71 72 1
R521 71 0 1000
R72 72 73 1
R522 72 0 1000
R73 73 74 1
R523 73 0 1000
R74 74 75 1
R524 74 0 1000
R75 75 76 1
R525 75 0 1000
R76 76 77 1
R526 76 0 1000
R77 77 78 1
R527 77 0 1000
R78 78 79 1
R528 78 0 1000
R79 79 80 1
R529 79 0 1000
R80 80 81 1
R530 80 0 1000
R81 81 82 1
R531 81 0 1000
R82 82 83 1
R532 82 0 1000
R83 83 84 1
R533 83 0 1000
R84 84 85 1
R534 84 0 1000
R85 85 86 1
R535 85 0 1000
R86 86 87 1
R536 86 0 1000
R87 87 88 1
R537 87 0 1000
R88 88 89 1
R538 88 0 1000
R89 89 90 1
R539 89 0 1000
R90 90 91 1
R540 90 0 1000
R91 91 92 1
R541 91 0 1000
R92 92 93 1
R542 92 0 1000
R93 93 94 1
R543 93 0 1000
R94 94 95 1
R544 94 0 1000
R95 95 96 1
R545 95 0 1000
R96 96 97 1
R546 96 0 1000
R97 97 98 1
R547 97 0 1000
R98 98 99 1
R548 98 0 1000
R99 99 100 1
R549 99 0 1000
R100 100 101 1
R550 100 0 1000
R101 101 102 1
R551 101 0 1000
R102 102 103 1
R552 102 0 1000
R103 103 104 1
R553 103 0 1000
R104 104 105 1
R554 104 0 1000
R105 105 106 1
R555 105 0 1000
R106 106 107 1
R556 106 0 1000
R107 107 108 1
R557 107 0 1000
R108 108 109 1
R558 108 0 1000
R109 109 110 1
R559 109 0 1000
R110 110 111 1
R560 110 0 1000
R111 111 112 1
R561 111 0 1000
R112 112 113 1
R562 112 0 1000
R113 113 114 1
R563 113 0 1000
R114 114 115 1
R564 114 0 1000
R115 115 116 1
R565 115 0 1000
R116 116 117 1
R566 116 0 1000
R117 117 118 1
R567 117 0 1000
R118 118 119 1
R568 118 0 1000
R119 119 120 1
R569 119 0 1000
R120 120 121 1
R570 120 0 1000
R121 121 122 1
R571 121 0 1000
R122 122 123 1
R572 122 0 1000
R123 123 124 1
R573 123 0 1000
R124 124 125 1
R574 124 0 1000
R125 125 126 1
R575 125 0 1000
R126 126 127 1
R576 126 0 1000
R127 127 128 1
R577 127 0 1000
R128 128 129 1
R578 128 0 1000
R129 129 130 1
R579 129 0 1000
R130 130 131 1
R580 130 0 1000
R131 131 132 1
R581 131 0 1000
R132 132 133 1
R582 132 0 1000
R133 133 134 1
R583 133 0 1000
R134 134 135 1
R584 134 0 1000
R135 135 136 1
R585 135 0 1000
R136 136 137 1
R586 136 0 1000
R137 137 138 1
R587 137 0 1000
R138 138 139 1
R588 138 0 1000
R139 139 140 1
R589 139 0 1000
R140 140 141 1
R590 140 0 1000
R141 141 142 1
R591 141 0 1000
R142 142 143 1
R592 142 0 1000
R143 143 144 1
R593 143 0 1000
R144 144 145 1
R594 144 0 1000
R145 145 146 1
R595 145 0 1000
R146 146 147 1
R596 146 0 1000
R147 147 148 1
R597 147 0 1000
R148 148 149 1
R598 148 0 1000
R149 149 150 1
R599 149 0 1000
R150 150 151 1
R600 150 0 1000
R151 151 152 1
R601 151 0 1000
R152 152 153 1
R602 152 0 1000
R153 153 154 1
R603 153 0 1000
R154 154 155 1
R604 154 0 1000
R155 155 156 1
R605 155 0 1000
R156 156 157 1
R606 156 0 1000
R157 157 158 1
R607 157 0 1000
R158 158 159 1
R608 158 0 1000
R159 159 160 1
R609 159 0 1000
R160 160 161 1
R610 160 0 1000
R161 161 162 1
R611 161 0 1000
R162 162 163 1
R612 162 0 1000
R163 163 164 1
R613 163 0 1000
R164 164 165 1
R614 164 0 1000
R165 165 166 1
R615 165 0 1000
R166 166 167 1
R616 166 0 1000
R167 167 168 1
R617 167 0 1000
R168 168 169 1
R618 168 0 1000
R169 169 170 1
R619 169 0 1000
R170 170 171 1
R620 170 0 1000
R171 171 172 1
R621 171 0 1000
R172 172 173 1
R622 172 0 1000
R173 173 174 1
R623 173 0 1000
R174 174 175 1
R624 174 0 1000
R175 175 176 1
R625 175 0 1000
R176 176 177 1
R626 176 0 1000
R177 177 178 1
R627 177 0 1000
R178 178 179 1
R628 178 0 1000
R179 179 180 1
R629 179 0 1000
R180 180 181 1
R630 180 0 1000
R181 181 182 1
R631 181 0 1000
R182 182 183 1
R632 182 0 1000
R183 183 184 1
R633 183 0 1000
R184 184 185 1
R634 184 0 1000
R185 185 186 1
R635 185 0 1000
R186 186 187 1
R636 186 0 1000
R187 187 188 1
R637 187 0 1000
R188 188 189 1
R638 188 0 1000
R189 189 190 1
R639 189 0 1000
R190 190 191 1
R640 190 0 1000
R191 191 192 1
R641 191 0 1000
R192 192 193 1
R642 192 0 1000
R193 193 194 1
R643 193 0 1000
R194 194 195 1
R644 194 0 1000
R195 195 196 1
R645 195 0 1000
R196 196 197 1
R646 196 0 1000
R197 197 198 1
R647 197 0 1000
R198 198 199 1
R648 198 0 1000
R199 199 200 1
R649 199 0 1000
R200 200 201 1
R650 200 0 1000
R201 201 202 1
R651 201 0 1000
R202 202 203 1
R652 202 0 1000
R203 203 204 1
R653 203 0 1000
R204 204 205 1
R654 204 0 1000
R205 205 206 1
R655 205 0 1000
R206 206 207 1
R656 206 0 1000
R207 207 208 1
R657 207 0 1000
R208 208 209 1
R658 208 0 1000
R209 209 210 1
R659 209 0 1000
R210 210 211 1
R660 210 0 1000
R211 211 212 1
R661 211 0 1000
R212 212 213 1
R662 212 0 1000
R213 213 214 1
R663 213 0 1000
R214 214 215 1
R664 214 0 1000
R215 215 216 1
R665 215 0 1000
R216 216 217 1
R666 216 0 1000
R217 217 218 1
R667 217 0 1000
R218 218 219 1
R668 218 0 1000
R219 219 220 1
R669 219 0 1000
R220 220 221 1
R670 220 0 1000
R221 221 222 1
R671 221 0 1000
R222 222 223 1
R672 222 0 1000
R223 223 224 1
R673 223 0 1000
R224 224 225 1
R674 224 0 1000
R225 225 226 1
R675 225 0 1000
R226 226 227 1
R676 226 0 1000
R227 227 228 1
R677 227 0 1000
R228 228 229 1
R678 228 0 1000
R229 229 230 1
R679 229 0 1000
R230 230 231 1
R680 230 0 1000
R231 231 232 1
R681 231 0 1000
R232 232 233 1
R682 232 0 1000
R233 233 234 1
R683 233 0 1000
R234 234 235 1
R684 234 0 1000
R235 235 236 1
R685 235 0 1000
R236 236 237 1
R686 236 0 1000
R237 237 238 1
R687 237 0 1000
R238 238 239 1
R688 238 0 1000
R239 239 240 1
R689 239 0 1000
R240 240 241 1
R690 240 0 1000
R241 241 242 1
R691 241 0 1000
R242 242 243 1
R692 242 0 1000
R243 243 244 1
R693 243 0 1000
R244 244 245 1
R694 244 0 1000
R245 245 246 1
R695 245 0 1000
R246 246 247 1
R696 246 0 1000
R247 247 248 1
R697 247 0 1000
R248 248 249 1
R698 248 0 1000
R249 249 250 1
R699 249 0 1000
R250 250 251 1
R700 250 0 1000
R251 251 252 1
R701 251 0 1000
R252 252 253 1
R702 252 0 1000
R253 253 254 1
R703 253 0 1000
R254 254 255 1
R704 254 0 1000
R255 255 256 1
R705 255 0 1000
R256 256 257 1
R706 256 0 1000
R257 257 258 1
R707 257 0 1000
R258 258 259 1
R708 258 0 1000
R259 259 260 1
R709 259 0 1000
R260 260 261 1
R710 260 0 1000
R261 261 262 1
R711 261 0 1000
R262 262 263 1
R712 262 0 1000
R263 263 264 1
R713 263 0 1000
R264 264 265 1
R714 264 0 1000
R265 265 266 1
R715 265 0 1000
R266 266 267 1
R716 266 0 1000
R267 267 268 1
R717 267 0 1000
R268 268 269 1
R718 268 0 1000
R269 269 270 1
R719 269 0 1000
R270 270 271 1
R720 270 0 1000
R271 271 272 1
R721 271 0 1000
R272 272 273 1
R722 272 0 1000
R273 273 274 1
R723 273 0 1000
R274 274 275 1
R724 274 0 1000
R275 275 276 1
R725 275 0 1000
R276 276 277 1
R726 276 0 1000
R277 277 278 1
R727 277 0 1000
R278 278 279 1
R728 278 0 1000
R279 279 280 1
R729 279 0 1000
R280 280 281 1
R730 280 0 1000
R281 281 282 1
R731 281 0 1000
R282 282 283 1
R732 282 0 1000
R283 283 284 1
R733 283 0 1000
R284 284 285 1
R734 284 0 1000
R285 285 286 1
R735 285 0 1000
R286 286 287 1
R736 286 0 1000
R287 287 288 1
R737 287 0 1000
R288 288 289 1
R738 288 0 1000
R289 289 290 1
R739 289 0 1000
R290 290 291 1
R740 290 0 1000
R291 291 292 1
R741 291 0 1000
R292 292 293 1
R742 292 0 1000
R293 293 294 1
R743 293 0 1000
R294 294 295 1
R744 294 0 1000
R295 295 296 1
R745 295 0 1000
R296 296 297 1
R746 296 0 1000
R297 297 298 1
R747 297 0 1000
R298 298 299 1
R748 298 0 1000
R299 299 300 1
R749 299 0 1000
R300 300 301 1
R750 300 0 1000
R301 301 302 1
R751 301 0 1000
R302 302 303 1
R752 302 0 1000
R303 303 304 1
R753 303 0 1000
R304 304 305 1
R754 304 0 1000
R305 305 306 1
R755 305 0 1000
R306 306 307 1
R756 306 0 1000
R307 307 308 1
R757 307 0 1000
R308 308 309 1
R758 308 0 1000
R309 309 310 1
R759 309 0 1000
R310 310 311 1
R760 310 0 1000
R311 311 312 1
R761 311 0 1000
R312 312 313 1
R762 312 0 1000
R313 313 314 1
R763 313 0 1000
R314 314 315 1
R764 314 0 1000
R315 315 316 1
R765 315 0 1000
R316 316 317 1
R766 316 0 1000
R317 317 318 1
R767 317 0 1000
R318 318 319 1
R768 318 0 1000
R319 319 320 1
R769 319 0 1000
R320 320 321 1
R770 320 0 1000
R321 321 322 1
R771 321 0 1000
R322 322 323 1
R772 322 0 1000
R323 323 324 1
R773 323 0 1000
R324 324 325 1
R774 324 0 1000
R325 325 326 1
R775 325 0 1000
R326 326 327 1
R776 326 0 1000
R327 327 328 1
R777 327 0 1000
R328 328 329 1
R778 328 0 1000
R329 329 330 1
R779 329 0 1000
R330 330 331 1
R780 330 0 1000
R331 331 332 1
R781 331 0 1000
R332 332 333 1
R782 332 0 1000
R333 333 334 1
R783 333 0 1000
R334 334 335 1
R784 334 0 1000
R335 335 336 1
R785 335 0 1000
R336 336 337 1
R786 336 0 1000
R337 337 338 1
R787 337 0 1000
R338 338 339 1
R788 338 0 1000
R339 339 340 1
R789 339 0 1000
R340 340 341 1
R790 340 0 1000
R341 341 342 1
R791 341 0 1000
R342 342 343 1
R792 342 0 1000
R343 343 344 1
R793 343 0 1000
R344 344 345 1
R794 344 0 1000
R345 345 346 1
R795 345 0 1000
R346 346 347 1
R796 346 0 1000
R347 347 348 1
R797 347 0 1000
R348 348 349 1
R798 348 0 1000
R349 349 350 1
R799 349 0 1000
R350 350 351 1
R800 350 0 1000
R351 351 352 1
R801 351 0 1000
R352 352 353 1
R802 352 0 1000
R353 353 354 1
R803 353 0 1000
R354 354 355 1
R804 354 0 1000
R355 355 356 1
R805 355 0 1000
R356 356 357 1
R806 356 0 1000
R357 357 358 1
R807 357 0 1000
R358 358 359 1
R808 358 0 1000
R359 359 360 1
R809 359 0 1000
R360 360 361 1
R810 360 0 1000
R361 361 362 1
R811 361 0 1000
R362 362 363 1
R812 362 0 1000
R363 363 364 1
R813 363 0 1000
R364 364 365 1
R814 364 0 1000
R365 365 366 1
R815 365 0 1000
R366 366 367 1
R816 366 0 1000
R367 367 368 1
R817 367 0 1000
R368 368 369 1
R818 368 0 1000
R369 369 370 1
R819 369 0 1000
R370 370 371 1
R820 370 0 1000
R371 371 372 1
R821 371 0 1000
R372 372 373 1
R822 372 0 1000
R373 373 374 1
R823 373 0 1000
R374 374 375 1
R824 374 0 1000
R375 375 376 1
R825 375 0 1000
R376 376 377 1
R826 376 0 1000
R377 377 378 1
R827 377 0 1000
R378 378 379 1
R828 378 0 1000
R379 379 380 1
R829 379 0 1000
R380 380 381 1
R830 380 0 1000
R381 381 382 1
R831 381 0 1000
R382 382 383 1
R832 382 0 1000
R383 383 384 1
R833 383 0 1000
R384 384 385 1
R834 384 0 1000
R385 385 386 1
R835 385 0 1000
R386 386 387 1
R836 386 0 1000
R387 387 388 1
R837 387 0 1000
R388 388 389 1
R838 388 0 1000
R389 389 390 1
R839 389 0 1000
R390 390 391 1
R840 390 0 1000
R391 391 392 1
R841 391 0 1000
R392 392 393 1
R842 392 0 1000
R393 393 394 1
R843 393 0 1000
R394 394 395 1
R844 394 0 1000
R395 395 396 1
R845 395 0 1000
R396 396 397 1
R846 396 0 1000
R397 397 398 1
R847 397 0 1000
R398 398 399 1
R848 398 0 1000
R399 399 400 1
R849 399 0 1000
R400 400 401 1
R850 400 0 1000
R401 401 402 1
R851 401 0 1000
R402 402 403 1
R852 402 0 1000
R403 403 404 1
R853 403 0 1000
R404 404 405 1
R854 404 0 1000
R405 405 406 1
R855 405 0 1000
R406 406 407 1
R856 406 0 1000
R407 407 408 1
R857 407 0 1000
R408 408 409 1
R858 408 0 1000
R409 409 410 1
R859 409 0 1000
R410 410 411 1
R860 410 0 1000
R411 411 412 1
R861 411 0 1000
R412 412 413 1
R862 412 0 1000
R413 413 414 1
R863 413 0 1000
R414 414 415 1
R864 414 0 1000
R415 415 416 1
R865 415 0 1000
R416 416 417 1
R866 416 0 1000
R417 417 418 1
R867 417 0 1000
R418 418 419 1
R868 418 0 1000
R419 419 420 1
R869 419 0 1000
R420 420 421 1
R870 420 0 1000
R421 421 422 1
R871 421 0 1000
R422 422 423 1
R872 422 0 1000
R423 423 424 1
R873 423 0 1000
R424 424 425 1
R874 424 0 1000
R425 425 426 1
R875 425 0 1000
R426 426 427 1
R876 426 0 1000
R427 427 428 1
R877 427 0 1000
R428 428 429 1
R878 428 0 1000
R429 429 430 1
R879 429 0 1000
R430 430 431 1
R880 430 0 1000
R431 431 432 1
R881 431 0 1000
R432 432 433 1
R882 432 0 1000
R433 433 434 1
R883 433 0 1000
R434 434 435 1
R884 434 0 1000
R435 435 436 1
R885 435 0 1000
R436 436 437 1
R886 436 0 1000
R437 437 438 1
R887 437 0 1000
R438 438 439 1
R888 438 0 1000
R439 439 440 1
R889 439 0 1000
R440 440 441 1
R890 440 0 1000
R441 441 442 1
R891 441 0 1000
R442 442 443 1
R892 442 0 1000
R443 443 444 1
R893 443 0 1000
R444 444 445 1
R894 444 0 1000
R445 445 446 1
R895 445 0 1000
R446 446 447 1
R896 446 0 1000
R447 447 448 1
R897 447 0 1000
R448 448 449 1
R898 448 0 1000
R449 449 450 1
R899 449 0 1000
.tran 0 3 0 0.001
.end
