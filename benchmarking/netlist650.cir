*650
V1 1 0 SINE(0 100 1)
R1 1 2 1
R651 1 0 1000
R2 2 3 1
R652 2 0 1000
R3 3 4 1
R653 3 0 1000
R4 4 5 1
R654 4 0 1000
R5 5 6 1
R655 5 0 1000
R6 6 7 1
R656 6 0 1000
R7 7 8 1
R657 7 0 1000
R8 8 9 1
R658 8 0 1000
R9 9 10 1
R659 9 0 1000
R10 10 11 1
R660 10 0 1000
R11 11 12 1
R661 11 0 1000
R12 12 13 1
R662 12 0 1000
R13 13 14 1
R663 13 0 1000
R14 14 15 1
R664 14 0 1000
R15 15 16 1
R665 15 0 1000
R16 16 17 1
R666 16 0 1000
R17 17 18 1
R667 17 0 1000
R18 18 19 1
R668 18 0 1000
R19 19 20 1
R669 19 0 1000
R20 20 21 1
R670 20 0 1000
R21 21 22 1
R671 21 0 1000
R22 22 23 1
R672 22 0 1000
R23 23 24 1
R673 23 0 1000
R24 24 25 1
R674 24 0 1000
R25 25 26 1
R675 25 0 1000
R26 26 27 1
R676 26 0 1000
R27 27 28 1
R677 27 0 1000
R28 28 29 1
R678 28 0 1000
R29 29 30 1
R679 29 0 1000
R30 30 31 1
R680 30 0 1000
R31 31 32 1
R681 31 0 1000
R32 32 33 1
R682 32 0 1000
R33 33 34 1
R683 33 0 1000
R34 34 35 1
R684 34 0 1000
R35 35 36 1
R685 35 0 1000
R36 36 37 1
R686 36 0 1000
R37 37 38 1
R687 37 0 1000
R38 38 39 1
R688 38 0 1000
R39 39 40 1
R689 39 0 1000
R40 40 41 1
R690 40 0 1000
R41 41 42 1
R691 41 0 1000
R42 42 43 1
R692 42 0 1000
R43 43 44 1
R693 43 0 1000
R44 44 45 1
R694 44 0 1000
R45 45 46 1
R695 45 0 1000
R46 46 47 1
R696 46 0 1000
R47 47 48 1
R697 47 0 1000
R48 48 49 1
R698 48 0 1000
R49 49 50 1
R699 49 0 1000
R50 50 51 1
R700 50 0 1000
R51 51 52 1
R701 51 0 1000
R52 52 53 1
R702 52 0 1000
R53 53 54 1
R703 53 0 1000
R54 54 55 1
R704 54 0 1000
R55 55 56 1
R705 55 0 1000
R56 56 57 1
R706 56 0 1000
R57 57 58 1
R707 57 0 1000
R58 58 59 1
R708 58 0 1000
R59 59 60 1
R709 59 0 1000
R60 60 61 1
R710 60 0 1000
R61 61 62 1
R711 61 0 1000
R62 62 63 1
R712 62 0 1000
R63 63 64 1
R713 63 0 1000
R64 64 65 1
R714 64 0 1000
R65 65 66 1
R715 65 0 1000
R66 66 67 1
R716 66 0 1000
R67 67 68 1
R717 67 0 1000
R68 68 69 1
R718 68 0 1000
R69 69 70 1
R719 69 0 1000
R70 70 71 1
R720 70 0 1000
R71 71 72 1
R721 71 0 1000
R72 72 73 1
R722 72 0 1000
R73 73 74 1
R723 73 0 1000
R74 74 75 1
R724 74 0 1000
R75 75 76 1
R725 75 0 1000
R76 76 77 1
R726 76 0 1000
R77 77 78 1
R727 77 0 1000
R78 78 79 1
R728 78 0 1000
R79 79 80 1
R729 79 0 1000
R80 80 81 1
R730 80 0 1000
R81 81 82 1
R731 81 0 1000
R82 82 83 1
R732 82 0 1000
R83 83 84 1
R733 83 0 1000
R84 84 85 1
R734 84 0 1000
R85 85 86 1
R735 85 0 1000
R86 86 87 1
R736 86 0 1000
R87 87 88 1
R737 87 0 1000
R88 88 89 1
R738 88 0 1000
R89 89 90 1
R739 89 0 1000
R90 90 91 1
R740 90 0 1000
R91 91 92 1
R741 91 0 1000
R92 92 93 1
R742 92 0 1000
R93 93 94 1
R743 93 0 1000
R94 94 95 1
R744 94 0 1000
R95 95 96 1
R745 95 0 1000
R96 96 97 1
R746 96 0 1000
R97 97 98 1
R747 97 0 1000
R98 98 99 1
R748 98 0 1000
R99 99 100 1
R749 99 0 1000
R100 100 101 1
R750 100 0 1000
R101 101 102 1
R751 101 0 1000
R102 102 103 1
R752 102 0 1000
R103 103 104 1
R753 103 0 1000
R104 104 105 1
R754 104 0 1000
R105 105 106 1
R755 105 0 1000
R106 106 107 1
R756 106 0 1000
R107 107 108 1
R757 107 0 1000
R108 108 109 1
R758 108 0 1000
R109 109 110 1
R759 109 0 1000
R110 110 111 1
R760 110 0 1000
R111 111 112 1
R761 111 0 1000
R112 112 113 1
R762 112 0 1000
R113 113 114 1
R763 113 0 1000
R114 114 115 1
R764 114 0 1000
R115 115 116 1
R765 115 0 1000
R116 116 117 1
R766 116 0 1000
R117 117 118 1
R767 117 0 1000
R118 118 119 1
R768 118 0 1000
R119 119 120 1
R769 119 0 1000
R120 120 121 1
R770 120 0 1000
R121 121 122 1
R771 121 0 1000
R122 122 123 1
R772 122 0 1000
R123 123 124 1
R773 123 0 1000
R124 124 125 1
R774 124 0 1000
R125 125 126 1
R775 125 0 1000
R126 126 127 1
R776 126 0 1000
R127 127 128 1
R777 127 0 1000
R128 128 129 1
R778 128 0 1000
R129 129 130 1
R779 129 0 1000
R130 130 131 1
R780 130 0 1000
R131 131 132 1
R781 131 0 1000
R132 132 133 1
R782 132 0 1000
R133 133 134 1
R783 133 0 1000
R134 134 135 1
R784 134 0 1000
R135 135 136 1
R785 135 0 1000
R136 136 137 1
R786 136 0 1000
R137 137 138 1
R787 137 0 1000
R138 138 139 1
R788 138 0 1000
R139 139 140 1
R789 139 0 1000
R140 140 141 1
R790 140 0 1000
R141 141 142 1
R791 141 0 1000
R142 142 143 1
R792 142 0 1000
R143 143 144 1
R793 143 0 1000
R144 144 145 1
R794 144 0 1000
R145 145 146 1
R795 145 0 1000
R146 146 147 1
R796 146 0 1000
R147 147 148 1
R797 147 0 1000
R148 148 149 1
R798 148 0 1000
R149 149 150 1
R799 149 0 1000
R150 150 151 1
R800 150 0 1000
R151 151 152 1
R801 151 0 1000
R152 152 153 1
R802 152 0 1000
R153 153 154 1
R803 153 0 1000
R154 154 155 1
R804 154 0 1000
R155 155 156 1
R805 155 0 1000
R156 156 157 1
R806 156 0 1000
R157 157 158 1
R807 157 0 1000
R158 158 159 1
R808 158 0 1000
R159 159 160 1
R809 159 0 1000
R160 160 161 1
R810 160 0 1000
R161 161 162 1
R811 161 0 1000
R162 162 163 1
R812 162 0 1000
R163 163 164 1
R813 163 0 1000
R164 164 165 1
R814 164 0 1000
R165 165 166 1
R815 165 0 1000
R166 166 167 1
R816 166 0 1000
R167 167 168 1
R817 167 0 1000
R168 168 169 1
R818 168 0 1000
R169 169 170 1
R819 169 0 1000
R170 170 171 1
R820 170 0 1000
R171 171 172 1
R821 171 0 1000
R172 172 173 1
R822 172 0 1000
R173 173 174 1
R823 173 0 1000
R174 174 175 1
R824 174 0 1000
R175 175 176 1
R825 175 0 1000
R176 176 177 1
R826 176 0 1000
R177 177 178 1
R827 177 0 1000
R178 178 179 1
R828 178 0 1000
R179 179 180 1
R829 179 0 1000
R180 180 181 1
R830 180 0 1000
R181 181 182 1
R831 181 0 1000
R182 182 183 1
R832 182 0 1000
R183 183 184 1
R833 183 0 1000
R184 184 185 1
R834 184 0 1000
R185 185 186 1
R835 185 0 1000
R186 186 187 1
R836 186 0 1000
R187 187 188 1
R837 187 0 1000
R188 188 189 1
R838 188 0 1000
R189 189 190 1
R839 189 0 1000
R190 190 191 1
R840 190 0 1000
R191 191 192 1
R841 191 0 1000
R192 192 193 1
R842 192 0 1000
R193 193 194 1
R843 193 0 1000
R194 194 195 1
R844 194 0 1000
R195 195 196 1
R845 195 0 1000
R196 196 197 1
R846 196 0 1000
R197 197 198 1
R847 197 0 1000
R198 198 199 1
R848 198 0 1000
R199 199 200 1
R849 199 0 1000
R200 200 201 1
R850 200 0 1000
R201 201 202 1
R851 201 0 1000
R202 202 203 1
R852 202 0 1000
R203 203 204 1
R853 203 0 1000
R204 204 205 1
R854 204 0 1000
R205 205 206 1
R855 205 0 1000
R206 206 207 1
R856 206 0 1000
R207 207 208 1
R857 207 0 1000
R208 208 209 1
R858 208 0 1000
R209 209 210 1
R859 209 0 1000
R210 210 211 1
R860 210 0 1000
R211 211 212 1
R861 211 0 1000
R212 212 213 1
R862 212 0 1000
R213 213 214 1
R863 213 0 1000
R214 214 215 1
R864 214 0 1000
R215 215 216 1
R865 215 0 1000
R216 216 217 1
R866 216 0 1000
R217 217 218 1
R867 217 0 1000
R218 218 219 1
R868 218 0 1000
R219 219 220 1
R869 219 0 1000
R220 220 221 1
R870 220 0 1000
R221 221 222 1
R871 221 0 1000
R222 222 223 1
R872 222 0 1000
R223 223 224 1
R873 223 0 1000
R224 224 225 1
R874 224 0 1000
R225 225 226 1
R875 225 0 1000
R226 226 227 1
R876 226 0 1000
R227 227 228 1
R877 227 0 1000
R228 228 229 1
R878 228 0 1000
R229 229 230 1
R879 229 0 1000
R230 230 231 1
R880 230 0 1000
R231 231 232 1
R881 231 0 1000
R232 232 233 1
R882 232 0 1000
R233 233 234 1
R883 233 0 1000
R234 234 235 1
R884 234 0 1000
R235 235 236 1
R885 235 0 1000
R236 236 237 1
R886 236 0 1000
R237 237 238 1
R887 237 0 1000
R238 238 239 1
R888 238 0 1000
R239 239 240 1
R889 239 0 1000
R240 240 241 1
R890 240 0 1000
R241 241 242 1
R891 241 0 1000
R242 242 243 1
R892 242 0 1000
R243 243 244 1
R893 243 0 1000
R244 244 245 1
R894 244 0 1000
R245 245 246 1
R895 245 0 1000
R246 246 247 1
R896 246 0 1000
R247 247 248 1
R897 247 0 1000
R248 248 249 1
R898 248 0 1000
R249 249 250 1
R899 249 0 1000
R250 250 251 1
R900 250 0 1000
R251 251 252 1
R901 251 0 1000
R252 252 253 1
R902 252 0 1000
R253 253 254 1
R903 253 0 1000
R254 254 255 1
R904 254 0 1000
R255 255 256 1
R905 255 0 1000
R256 256 257 1
R906 256 0 1000
R257 257 258 1
R907 257 0 1000
R258 258 259 1
R908 258 0 1000
R259 259 260 1
R909 259 0 1000
R260 260 261 1
R910 260 0 1000
R261 261 262 1
R911 261 0 1000
R262 262 263 1
R912 262 0 1000
R263 263 264 1
R913 263 0 1000
R264 264 265 1
R914 264 0 1000
R265 265 266 1
R915 265 0 1000
R266 266 267 1
R916 266 0 1000
R267 267 268 1
R917 267 0 1000
R268 268 269 1
R918 268 0 1000
R269 269 270 1
R919 269 0 1000
R270 270 271 1
R920 270 0 1000
R271 271 272 1
R921 271 0 1000
R272 272 273 1
R922 272 0 1000
R273 273 274 1
R923 273 0 1000
R274 274 275 1
R924 274 0 1000
R275 275 276 1
R925 275 0 1000
R276 276 277 1
R926 276 0 1000
R277 277 278 1
R927 277 0 1000
R278 278 279 1
R928 278 0 1000
R279 279 280 1
R929 279 0 1000
R280 280 281 1
R930 280 0 1000
R281 281 282 1
R931 281 0 1000
R282 282 283 1
R932 282 0 1000
R283 283 284 1
R933 283 0 1000
R284 284 285 1
R934 284 0 1000
R285 285 286 1
R935 285 0 1000
R286 286 287 1
R936 286 0 1000
R287 287 288 1
R937 287 0 1000
R288 288 289 1
R938 288 0 1000
R289 289 290 1
R939 289 0 1000
R290 290 291 1
R940 290 0 1000
R291 291 292 1
R941 291 0 1000
R292 292 293 1
R942 292 0 1000
R293 293 294 1
R943 293 0 1000
R294 294 295 1
R944 294 0 1000
R295 295 296 1
R945 295 0 1000
R296 296 297 1
R946 296 0 1000
R297 297 298 1
R947 297 0 1000
R298 298 299 1
R948 298 0 1000
R299 299 300 1
R949 299 0 1000
R300 300 301 1
R950 300 0 1000
R301 301 302 1
R951 301 0 1000
R302 302 303 1
R952 302 0 1000
R303 303 304 1
R953 303 0 1000
R304 304 305 1
R954 304 0 1000
R305 305 306 1
R955 305 0 1000
R306 306 307 1
R956 306 0 1000
R307 307 308 1
R957 307 0 1000
R308 308 309 1
R958 308 0 1000
R309 309 310 1
R959 309 0 1000
R310 310 311 1
R960 310 0 1000
R311 311 312 1
R961 311 0 1000
R312 312 313 1
R962 312 0 1000
R313 313 314 1
R963 313 0 1000
R314 314 315 1
R964 314 0 1000
R315 315 316 1
R965 315 0 1000
R316 316 317 1
R966 316 0 1000
R317 317 318 1
R967 317 0 1000
R318 318 319 1
R968 318 0 1000
R319 319 320 1
R969 319 0 1000
R320 320 321 1
R970 320 0 1000
R321 321 322 1
R971 321 0 1000
R322 322 323 1
R972 322 0 1000
R323 323 324 1
R973 323 0 1000
R324 324 325 1
R974 324 0 1000
R325 325 326 1
R975 325 0 1000
R326 326 327 1
R976 326 0 1000
R327 327 328 1
R977 327 0 1000
R328 328 329 1
R978 328 0 1000
R329 329 330 1
R979 329 0 1000
R330 330 331 1
R980 330 0 1000
R331 331 332 1
R981 331 0 1000
R332 332 333 1
R982 332 0 1000
R333 333 334 1
R983 333 0 1000
R334 334 335 1
R984 334 0 1000
R335 335 336 1
R985 335 0 1000
R336 336 337 1
R986 336 0 1000
R337 337 338 1
R987 337 0 1000
R338 338 339 1
R988 338 0 1000
R339 339 340 1
R989 339 0 1000
R340 340 341 1
R990 340 0 1000
R341 341 342 1
R991 341 0 1000
R342 342 343 1
R992 342 0 1000
R343 343 344 1
R993 343 0 1000
R344 344 345 1
R994 344 0 1000
R345 345 346 1
R995 345 0 1000
R346 346 347 1
R996 346 0 1000
R347 347 348 1
R997 347 0 1000
R348 348 349 1
R998 348 0 1000
R349 349 350 1
R999 349 0 1000
R350 350 351 1
R1000 350 0 1000
R351 351 352 1
R1001 351 0 1000
R352 352 353 1
R1002 352 0 1000
R353 353 354 1
R1003 353 0 1000
R354 354 355 1
R1004 354 0 1000
R355 355 356 1
R1005 355 0 1000
R356 356 357 1
R1006 356 0 1000
R357 357 358 1
R1007 357 0 1000
R358 358 359 1
R1008 358 0 1000
R359 359 360 1
R1009 359 0 1000
R360 360 361 1
R1010 360 0 1000
R361 361 362 1
R1011 361 0 1000
R362 362 363 1
R1012 362 0 1000
R363 363 364 1
R1013 363 0 1000
R364 364 365 1
R1014 364 0 1000
R365 365 366 1
R1015 365 0 1000
R366 366 367 1
R1016 366 0 1000
R367 367 368 1
R1017 367 0 1000
R368 368 369 1
R1018 368 0 1000
R369 369 370 1
R1019 369 0 1000
R370 370 371 1
R1020 370 0 1000
R371 371 372 1
R1021 371 0 1000
R372 372 373 1
R1022 372 0 1000
R373 373 374 1
R1023 373 0 1000
R374 374 375 1
R1024 374 0 1000
R375 375 376 1
R1025 375 0 1000
R376 376 377 1
R1026 376 0 1000
R377 377 378 1
R1027 377 0 1000
R378 378 379 1
R1028 378 0 1000
R379 379 380 1
R1029 379 0 1000
R380 380 381 1
R1030 380 0 1000
R381 381 382 1
R1031 381 0 1000
R382 382 383 1
R1032 382 0 1000
R383 383 384 1
R1033 383 0 1000
R384 384 385 1
R1034 384 0 1000
R385 385 386 1
R1035 385 0 1000
R386 386 387 1
R1036 386 0 1000
R387 387 388 1
R1037 387 0 1000
R388 388 389 1
R1038 388 0 1000
R389 389 390 1
R1039 389 0 1000
R390 390 391 1
R1040 390 0 1000
R391 391 392 1
R1041 391 0 1000
R392 392 393 1
R1042 392 0 1000
R393 393 394 1
R1043 393 0 1000
R394 394 395 1
R1044 394 0 1000
R395 395 396 1
R1045 395 0 1000
R396 396 397 1
R1046 396 0 1000
R397 397 398 1
R1047 397 0 1000
R398 398 399 1
R1048 398 0 1000
R399 399 400 1
R1049 399 0 1000
R400 400 401 1
R1050 400 0 1000
R401 401 402 1
R1051 401 0 1000
R402 402 403 1
R1052 402 0 1000
R403 403 404 1
R1053 403 0 1000
R404 404 405 1
R1054 404 0 1000
R405 405 406 1
R1055 405 0 1000
R406 406 407 1
R1056 406 0 1000
R407 407 408 1
R1057 407 0 1000
R408 408 409 1
R1058 408 0 1000
R409 409 410 1
R1059 409 0 1000
R410 410 411 1
R1060 410 0 1000
R411 411 412 1
R1061 411 0 1000
R412 412 413 1
R1062 412 0 1000
R413 413 414 1
R1063 413 0 1000
R414 414 415 1
R1064 414 0 1000
R415 415 416 1
R1065 415 0 1000
R416 416 417 1
R1066 416 0 1000
R417 417 418 1
R1067 417 0 1000
R418 418 419 1
R1068 418 0 1000
R419 419 420 1
R1069 419 0 1000
R420 420 421 1
R1070 420 0 1000
R421 421 422 1
R1071 421 0 1000
R422 422 423 1
R1072 422 0 1000
R423 423 424 1
R1073 423 0 1000
R424 424 425 1
R1074 424 0 1000
R425 425 426 1
R1075 425 0 1000
R426 426 427 1
R1076 426 0 1000
R427 427 428 1
R1077 427 0 1000
R428 428 429 1
R1078 428 0 1000
R429 429 430 1
R1079 429 0 1000
R430 430 431 1
R1080 430 0 1000
R431 431 432 1
R1081 431 0 1000
R432 432 433 1
R1082 432 0 1000
R433 433 434 1
R1083 433 0 1000
R434 434 435 1
R1084 434 0 1000
R435 435 436 1
R1085 435 0 1000
R436 436 437 1
R1086 436 0 1000
R437 437 438 1
R1087 437 0 1000
R438 438 439 1
R1088 438 0 1000
R439 439 440 1
R1089 439 0 1000
R440 440 441 1
R1090 440 0 1000
R441 441 442 1
R1091 441 0 1000
R442 442 443 1
R1092 442 0 1000
R443 443 444 1
R1093 443 0 1000
R444 444 445 1
R1094 444 0 1000
R445 445 446 1
R1095 445 0 1000
R446 446 447 1
R1096 446 0 1000
R447 447 448 1
R1097 447 0 1000
R448 448 449 1
R1098 448 0 1000
R449 449 450 1
R1099 449 0 1000
R450 450 451 1
R1100 450 0 1000
R451 451 452 1
R1101 451 0 1000
R452 452 453 1
R1102 452 0 1000
R453 453 454 1
R1103 453 0 1000
R454 454 455 1
R1104 454 0 1000
R455 455 456 1
R1105 455 0 1000
R456 456 457 1
R1106 456 0 1000
R457 457 458 1
R1107 457 0 1000
R458 458 459 1
R1108 458 0 1000
R459 459 460 1
R1109 459 0 1000
R460 460 461 1
R1110 460 0 1000
R461 461 462 1
R1111 461 0 1000
R462 462 463 1
R1112 462 0 1000
R463 463 464 1
R1113 463 0 1000
R464 464 465 1
R1114 464 0 1000
R465 465 466 1
R1115 465 0 1000
R466 466 467 1
R1116 466 0 1000
R467 467 468 1
R1117 467 0 1000
R468 468 469 1
R1118 468 0 1000
R469 469 470 1
R1119 469 0 1000
R470 470 471 1
R1120 470 0 1000
R471 471 472 1
R1121 471 0 1000
R472 472 473 1
R1122 472 0 1000
R473 473 474 1
R1123 473 0 1000
R474 474 475 1
R1124 474 0 1000
R475 475 476 1
R1125 475 0 1000
R476 476 477 1
R1126 476 0 1000
R477 477 478 1
R1127 477 0 1000
R478 478 479 1
R1128 478 0 1000
R479 479 480 1
R1129 479 0 1000
R480 480 481 1
R1130 480 0 1000
R481 481 482 1
R1131 481 0 1000
R482 482 483 1
R1132 482 0 1000
R483 483 484 1
R1133 483 0 1000
R484 484 485 1
R1134 484 0 1000
R485 485 486 1
R1135 485 0 1000
R486 486 487 1
R1136 486 0 1000
R487 487 488 1
R1137 487 0 1000
R488 488 489 1
R1138 488 0 1000
R489 489 490 1
R1139 489 0 1000
R490 490 491 1
R1140 490 0 1000
R491 491 492 1
R1141 491 0 1000
R492 492 493 1
R1142 492 0 1000
R493 493 494 1
R1143 493 0 1000
R494 494 495 1
R1144 494 0 1000
R495 495 496 1
R1145 495 0 1000
R496 496 497 1
R1146 496 0 1000
R497 497 498 1
R1147 497 0 1000
R498 498 499 1
R1148 498 0 1000
R499 499 500 1
R1149 499 0 1000
R500 500 501 1
R1150 500 0 1000
R501 501 502 1
R1151 501 0 1000
R502 502 503 1
R1152 502 0 1000
R503 503 504 1
R1153 503 0 1000
R504 504 505 1
R1154 504 0 1000
R505 505 506 1
R1155 505 0 1000
R506 506 507 1
R1156 506 0 1000
R507 507 508 1
R1157 507 0 1000
R508 508 509 1
R1158 508 0 1000
R509 509 510 1
R1159 509 0 1000
R510 510 511 1
R1160 510 0 1000
R511 511 512 1
R1161 511 0 1000
R512 512 513 1
R1162 512 0 1000
R513 513 514 1
R1163 513 0 1000
R514 514 515 1
R1164 514 0 1000
R515 515 516 1
R1165 515 0 1000
R516 516 517 1
R1166 516 0 1000
R517 517 518 1
R1167 517 0 1000
R518 518 519 1
R1168 518 0 1000
R519 519 520 1
R1169 519 0 1000
R520 520 521 1
R1170 520 0 1000
R521 521 522 1
R1171 521 0 1000
R522 522 523 1
R1172 522 0 1000
R523 523 524 1
R1173 523 0 1000
R524 524 525 1
R1174 524 0 1000
R525 525 526 1
R1175 525 0 1000
R526 526 527 1
R1176 526 0 1000
R527 527 528 1
R1177 527 0 1000
R528 528 529 1
R1178 528 0 1000
R529 529 530 1
R1179 529 0 1000
R530 530 531 1
R1180 530 0 1000
R531 531 532 1
R1181 531 0 1000
R532 532 533 1
R1182 532 0 1000
R533 533 534 1
R1183 533 0 1000
R534 534 535 1
R1184 534 0 1000
R535 535 536 1
R1185 535 0 1000
R536 536 537 1
R1186 536 0 1000
R537 537 538 1
R1187 537 0 1000
R538 538 539 1
R1188 538 0 1000
R539 539 540 1
R1189 539 0 1000
R540 540 541 1
R1190 540 0 1000
R541 541 542 1
R1191 541 0 1000
R542 542 543 1
R1192 542 0 1000
R543 543 544 1
R1193 543 0 1000
R544 544 545 1
R1194 544 0 1000
R545 545 546 1
R1195 545 0 1000
R546 546 547 1
R1196 546 0 1000
R547 547 548 1
R1197 547 0 1000
R548 548 549 1
R1198 548 0 1000
R549 549 550 1
R1199 549 0 1000
R550 550 551 1
R1200 550 0 1000
R551 551 552 1
R1201 551 0 1000
R552 552 553 1
R1202 552 0 1000
R553 553 554 1
R1203 553 0 1000
R554 554 555 1
R1204 554 0 1000
R555 555 556 1
R1205 555 0 1000
R556 556 557 1
R1206 556 0 1000
R557 557 558 1
R1207 557 0 1000
R558 558 559 1
R1208 558 0 1000
R559 559 560 1
R1209 559 0 1000
R560 560 561 1
R1210 560 0 1000
R561 561 562 1
R1211 561 0 1000
R562 562 563 1
R1212 562 0 1000
R563 563 564 1
R1213 563 0 1000
R564 564 565 1
R1214 564 0 1000
R565 565 566 1
R1215 565 0 1000
R566 566 567 1
R1216 566 0 1000
R567 567 568 1
R1217 567 0 1000
R568 568 569 1
R1218 568 0 1000
R569 569 570 1
R1219 569 0 1000
R570 570 571 1
R1220 570 0 1000
R571 571 572 1
R1221 571 0 1000
R572 572 573 1
R1222 572 0 1000
R573 573 574 1
R1223 573 0 1000
R574 574 575 1
R1224 574 0 1000
R575 575 576 1
R1225 575 0 1000
R576 576 577 1
R1226 576 0 1000
R577 577 578 1
R1227 577 0 1000
R578 578 579 1
R1228 578 0 1000
R579 579 580 1
R1229 579 0 1000
R580 580 581 1
R1230 580 0 1000
R581 581 582 1
R1231 581 0 1000
R582 582 583 1
R1232 582 0 1000
R583 583 584 1
R1233 583 0 1000
R584 584 585 1
R1234 584 0 1000
R585 585 586 1
R1235 585 0 1000
R586 586 587 1
R1236 586 0 1000
R587 587 588 1
R1237 587 0 1000
R588 588 589 1
R1238 588 0 1000
R589 589 590 1
R1239 589 0 1000
R590 590 591 1
R1240 590 0 1000
R591 591 592 1
R1241 591 0 1000
R592 592 593 1
R1242 592 0 1000
R593 593 594 1
R1243 593 0 1000
R594 594 595 1
R1244 594 0 1000
R595 595 596 1
R1245 595 0 1000
R596 596 597 1
R1246 596 0 1000
R597 597 598 1
R1247 597 0 1000
R598 598 599 1
R1248 598 0 1000
R599 599 600 1
R1249 599 0 1000
R600 600 601 1
R1250 600 0 1000
R601 601 602 1
R1251 601 0 1000
R602 602 603 1
R1252 602 0 1000
R603 603 604 1
R1253 603 0 1000
R604 604 605 1
R1254 604 0 1000
R605 605 606 1
R1255 605 0 1000
R606 606 607 1
R1256 606 0 1000
R607 607 608 1
R1257 607 0 1000
R608 608 609 1
R1258 608 0 1000
R609 609 610 1
R1259 609 0 1000
R610 610 611 1
R1260 610 0 1000
R611 611 612 1
R1261 611 0 1000
R612 612 613 1
R1262 612 0 1000
R613 613 614 1
R1263 613 0 1000
R614 614 615 1
R1264 614 0 1000
R615 615 616 1
R1265 615 0 1000
R616 616 617 1
R1266 616 0 1000
R617 617 618 1
R1267 617 0 1000
R618 618 619 1
R1268 618 0 1000
R619 619 620 1
R1269 619 0 1000
R620 620 621 1
R1270 620 0 1000
R621 621 622 1
R1271 621 0 1000
R622 622 623 1
R1272 622 0 1000
R623 623 624 1
R1273 623 0 1000
R624 624 625 1
R1274 624 0 1000
R625 625 626 1
R1275 625 0 1000
R626 626 627 1
R1276 626 0 1000
R627 627 628 1
R1277 627 0 1000
R628 628 629 1
R1278 628 0 1000
R629 629 630 1
R1279 629 0 1000
R630 630 631 1
R1280 630 0 1000
R631 631 632 1
R1281 631 0 1000
R632 632 633 1
R1282 632 0 1000
R633 633 634 1
R1283 633 0 1000
R634 634 635 1
R1284 634 0 1000
R635 635 636 1
R1285 635 0 1000
R636 636 637 1
R1286 636 0 1000
R637 637 638 1
R1287 637 0 1000
R638 638 639 1
R1288 638 0 1000
R639 639 640 1
R1289 639 0 1000
R640 640 641 1
R1290 640 0 1000
R641 641 642 1
R1291 641 0 1000
R642 642 643 1
R1292 642 0 1000
R643 643 644 1
R1293 643 0 1000
R644 644 645 1
R1294 644 0 1000
R645 645 646 1
R1295 645 0 1000
R646 646 647 1
R1296 646 0 1000
R647 647 648 1
R1297 647 0 1000
R648 648 649 1
R1298 648 0 1000
R649 649 650 1
R1299 649 0 1000
.tran 0 3 0 0.001
.end
